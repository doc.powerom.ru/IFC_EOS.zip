Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-04-23T19:02:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181217_1515(x64) - Exporter 19.2.0.65 - Альтернативный интерфейс 19.2.0.65
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Apr 23 19:02:21 2024 * Host: WIN-0P1AU7TJQME * Database: C:\Users\user\AppData\Local\Temp\{E286D05D-7172-44AE-AF52-C42B6FC42140}\ifc * Database version: 5507 * Database creation date: Tue Apr 23 19:02:20 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Apr 23 19:02:20 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Apr 23 19:02:20 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2022
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2022
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее(Type) - Категория: Уровни; Имя семейства: Уровень
Идентификация(Type) - Имя типа: Отметка уровня с именем
Зависимости(Type) - Базовая отметка: Базовая точка проекта
Графика(Type) - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: Сплошная; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Зависимости - Фасад: 0 mm
Идентификация - Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Прочее - Категория: Уровни; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: EOS Power On-grid 20 кВт, EOS_СолнечныйИнвертор_ТрехфазныйСетевой_EOS-Power-On-grid_20-33кВт_DKC:EOS Power On-grid 20 кВт:625022
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Корпус_Белый, DKC_Корпус_Светло-серый, DKC_Радиатор_Светло-серый
Type - Данные - ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPG030D020A; ADSK_Количество: 1; ADSK_Марка: EOS Power On-grid; ADSK_Масса: 20; ADSK_Масса_Текст: 20; ADSK_Материал: DKC_Корпус_Белый; ADSK_Наименование: Сетевой трёхфазный солнечный инвертор EOS Power On-grid 20 кВт; ADSK_Наименование краткое: Инвертор EOS Power On-grid 20 кВт
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/da5/8lod1plmysrnohigtahcz8wsdy0d0t3z.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1740/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power On-grid 20 кВт; Описание: Сетевыми (on-grid) инверторами являются устройства, преобразующие постоянное (DC) напряжение от солнечных панелей в переменное (AC) напряжение, и передающие его напрямую в сеть 220 (или 380) В, с надлежащими значениями частоты и фазы для сопряжения со стационарной сетью, тем самым снижая потребление электроэнергии от энергосетей.
Type - Материалы и отделка - Материал_Корпус_Детали: DKC_Корпус_Черный; Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ТрехфазныйСетевой_EOS-Power-On-grid_20-33кВт_DKC; Интерфейсы связи: RS485, GPRS (опционально), Wi-Fi (опционально), 4G (опционально); Рабочая температура: - 25°С ~ 60°С; Степень защиты: IP 66
Type - Размеры - ADSK_Размер_Высота: 480 mm; ADSK_Размер_Глубина: 215 mm; ADSK_Размер_Ширина: 320 mm
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Коэффициент мощности: 0.99; ADSK_КПД: 98.2; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 20000 W; ADSK_Полная мощность: 20202 W; ADSK_Ток: 60 A
Pset_BuildingElementProxyCommon - Reference: EOS Power On-grid 20 кВт
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Марка: 17
Прочее - Код типа: EOS_СолнечныйИнвертор_ТрехфазныйСетевой_EOS-Power-On-grid_20-33кВт_DKC: EOS Power On-grid 20 кВт; Семейство: EOS_СолнечныйИнвертор_ТрехфазныйСетевой_EOS-Power-On-grid_20-33кВт_DKC: EOS Power On-grid 20 кВт; Семейство и типоразмер: EOS_СолнечныйИнвертор_ТрехфазныйСетевой_EOS-Power-On-grid_20-33кВт_DKC: EOS Power On-grid 20 кВт; Тип: EOS_СолнечныйИнвертор_ТрехфазныйСетевой_EOS-Power-On-grid_20-33кВт_DKC: EOS Power On-grid 20 кВт
Размеры - Объем: 0.0357887 m3; Площадь: 0.34 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-20202 В·А

# IfcBuildingElementProxy: EOS Power On-grid 25 кВт, EOS_СолнечныйИнвертор_ТрехфазныйСетевой_EOS-Power-On-grid_20-33кВт_DKC:EOS Power On-grid 25 кВт:625023
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Корпус_Белый, DKC_Корпус_Светло-серый, DKC_Радиатор_Светло-серый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Белый; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPG037D025A; ADSK_Марка: EOS Power On-grid; ADSK_Масса: 20; ADSK_Масса_Текст: 20; ADSK_Наименование: Сетевой трёхфазный солнечный инвертор EOS Power On-grid 25 кВт; ADSK_Наименование краткое: Инвертор EOS Power On-grid 25 кВт
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/da5/8lod1plmysrnohigtahcz8wsdy0d0t3z.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1740/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power On-grid 25 кВт; Описание: Сетевыми (on-grid) инверторами являются устройства, преобразующие постоянное (DC) напряжение от солнечных панелей в переменное (AC) напряжение, и передающие его напрямую в сеть 220 (или 380) В, с надлежащими значениями частоты и фазы для сопряжения со стационарной сетью, тем самым снижая потребление электроэнергии от энергосетей.
Type - Материалы и отделка - Материал_Корпус_Детали: DKC_Корпус_Черный; Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ТрехфазныйСетевой_EOS-Power-On-grid_20-33кВт_DKC; Интерфейсы связи: RS485, GPRS (опционально), Wi-Fi (опционально), 4G (опционально); Рабочая температура: - 25°С ~ 60°С; Степень защиты: IP 66
Type - Размеры - ADSK_Размер_Высота: 480 mm; ADSK_Размер_Глубина: 215 mm; ADSK_Размер_Ширина: 320 mm
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Коэффициент мощности: 0.99; ADSK_КПД: 98.2; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 25000 W; ADSK_Полная мощность: 25252.5 W; ADSK_Ток: 60 A
Pset_BuildingElementProxyCommon - Reference: EOS Power On-grid 25 кВт
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Идентификация - Марка: 18
Прочее - Код типа: EOS_СолнечныйИнвертор_ТрехфазныйСетевой_EOS-Power-On-grid_20-33кВт_DKC: EOS Power On-grid 25 кВт; Семейство: EOS_СолнечныйИнвертор_ТрехфазныйСетевой_EOS-Power-On-grid_20-33кВт_DKC: EOS Power On-grid 25 кВт; Семейство и типоразмер: EOS_СолнечныйИнвертор_ТрехфазныйСетевой_EOS-Power-On-grid_20-33кВт_DKC: EOS Power On-grid 25 кВт; Тип: EOS_СолнечныйИнвертор_ТрехфазныйСетевой_EOS-Power-On-grid_20-33кВт_DKC: EOS Power On-grid 25 кВт
Размеры - Объем: 0.0357887 m3; Площадь: 0.34 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-25253 В·А

# IfcBuildingElementProxy: EOS Power On-grid 30 кВт, EOS_СолнечныйИнвертор_ТрехфазныйСетевой_EOS-Power-On-grid_20-33кВт_DKC:EOS Power On-grid 30 кВт:625024
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Корпус_Белый, DKC_Корпус_Светло-серый, DKC_Радиатор_Светло-серый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Белый; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPG045D030A; ADSK_Марка: EOS Power On-grid; ADSK_Масса: 23; ADSK_Масса_Текст: 23; ADSK_Наименование: Сетевой трёхфазный солнечный инвертор EOS Power On-grid 30 кВт; ADSK_Наименование краткое: Инвертор EOS Power On-grid 30 кВт
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/da5/8lod1plmysrnohigtahcz8wsdy0d0t3z.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1740/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power On-grid 30 кВт; Описание: Сетевыми (on-grid) инверторами являются устройства, преобразующие постоянное (DC) напряжение от солнечных панелей в переменное (AC) напряжение, и передающие его напрямую в сеть 220 (или 380) В, с надлежащими значениями частоты и фазы для сопряжения со стационарной сетью, тем самым снижая потребление электроэнергии от энергосетей.
Type - Материалы и отделка - Материал_Корпус_Детали: DKC_Корпус_Черный; Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ТрехфазныйСетевой_EOS-Power-On-grid_20-33кВт_DKC; Интерфейсы связи: RS485, GPRS (опционально), Wi-Fi (опционально), 4G (опционально); Рабочая температура: - 25°С ~ 60°С; Степень защиты: IP 66
Type - Размеры - ADSK_Размер_Высота: 480 mm; ADSK_Размер_Глубина: 215 mm; ADSK_Размер_Ширина: 320 mm
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Коэффициент мощности: 0.99; ADSK_КПД: 98.2; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 30000 W; ADSK_Полная мощность: 30303 W; ADSK_Ток: 60 A
Pset_BuildingElementProxyCommon - Reference: EOS Power On-grid 30 кВт
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 19
Прочее - Код типа: EOS_СолнечныйИнвертор_ТрехфазныйСетевой_EOS-Power-On-grid_20-33кВт_DKC: EOS Power On-grid 30 кВт; Семейство: EOS_СолнечныйИнвертор_ТрехфазныйСетевой_EOS-Power-On-grid_20-33кВт_DKC: EOS Power On-grid 30 кВт; Семейство и типоразмер: EOS_СолнечныйИнвертор_ТрехфазныйСетевой_EOS-Power-On-grid_20-33кВт_DKC: EOS Power On-grid 30 кВт; Тип: EOS_СолнечныйИнвертор_ТрехфазныйСетевой_EOS-Power-On-grid_20-33кВт_DKC: EOS Power On-grid 30 кВт
Размеры - Объем: 0.0357887 m3; Площадь: 0.34 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-30303 В·А

# IfcBuildingElementProxy: EOS Power On-grid 33 кВт, EOS_СолнечныйИнвертор_ТрехфазныйСетевой_EOS-Power-On-grid_20-33кВт_DKC:EOS Power On-grid 33 кВт:625025
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Корпус_Белый, DKC_Корпус_Светло-серый, DKC_Радиатор_Светло-серый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Белый; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPG045D033A; ADSK_Марка: EOS Power On-grid; ADSK_Масса: 23; ADSK_Масса_Текст: 23; ADSK_Наименование: Сетевой трёхфазный солнечный инвертор EOS Power On-grid 33 кВт; ADSK_Наименование краткое: Инвертор EOS Power On-grid 33 кВт
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/da5/8lod1plmysrnohigtahcz8wsdy0d0t3z.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1740/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power On-grid 33 кВт; Описание: Сетевыми (on-grid) инверторами являются устройства, преобразующие постоянное (DC) напряжение от солнечных панелей в переменное (AC) напряжение, и передающие его напрямую в сеть 220 (или 380) В, с надлежащими значениями частоты и фазы для сопряжения со стационарной сетью, тем самым снижая потребление электроэнергии от энергосетей.
Type - Материалы и отделка - Материал_Корпус_Детали: DKC_Корпус_Черный; Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ТрехфазныйСетевой_EOS-Power-On-grid_20-33кВт_DKC; Интерфейсы связи: RS485, GPRS (опционально), Wi-Fi (опционально), 4G (опционально); Рабочая температура: - 25°С ~ 60°С; Степень защиты: IP 66
Type - Размеры - ADSK_Размер_Высота: 480 mm; ADSK_Размер_Глубина: 215 mm; ADSK_Размер_Ширина: 320 mm
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Коэффициент мощности: 0.99; ADSK_КПД: 98.2; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 33000 W; ADSK_Полная мощность: 33333.3 W; ADSK_Ток: 80 A
Pset_BuildingElementProxyCommon - Reference: EOS Power On-grid 33 кВт
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 20
Прочее - Код типа: EOS_СолнечныйИнвертор_ТрехфазныйСетевой_EOS-Power-On-grid_20-33кВт_DKC: EOS Power On-grid 33 кВт; Семейство: EOS_СолнечныйИнвертор_ТрехфазныйСетевой_EOS-Power-On-grid_20-33кВт_DKC: EOS Power On-grid 33 кВт; Семейство и типоразмер: EOS_СолнечныйИнвертор_ТрехфазныйСетевой_EOS-Power-On-grid_20-33кВт_DKC: EOS Power On-grid 33 кВт; Тип: EOS_СолнечныйИнвертор_ТрехфазныйСетевой_EOS-Power-On-grid_20-33кВт_DKC: EOS Power On-grid 33 кВт
Размеры - Объем: 0.0357887 m3; Площадь: 0.34 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-33333 В·А

# IfcBuildingElementProxy: Текст модели:75 мм Arial (4)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 75 мм Arial
Графика - Горизонтальное выравнивание: По центру
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели
Материалы и отделка - Материал: DKC_СерыйЛого
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 75 мм Arial; Семейство: Текст модели: 75 мм Arial; Семейство и типоразмер: Текст модели: 75 мм Arial; Тип: Текст модели: 75 мм Arial
Размеры - Глубина:: 5 mm
Стадии - Стадия возведения: Стадия 1
Идентификация(Type) - Имя типа: 75 мм Arial
Прочее(Type) - Категория: Обобщенные модели; Имя семейства: Текст модели
Текст(Type) - Жирный: no; Курсив: no; Размер текста: 75 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст | Вариант конструкции
75 мм Arial | 20 кВт | Оформление каталога : Оформление каталога
75 мм Arial | 25 кВт | Оформление каталога (основной)
75 мм Arial | 30 кВт | Оформление каталога : Оформление каталога
75 мм Arial | 33 кВт | Оформление каталога (основной)
