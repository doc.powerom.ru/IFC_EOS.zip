Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-04-23T19:00:09
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181217_1515(x64) - Exporter 19.2.0.65 - Альтернативный интерфейс 19.2.0.65
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Apr 23 19:00:09 2024 * Host: WIN-0P1AU7TJQME * Database: C:\Users\user\AppData\Local\Temp\{BBD8E6B2-537E-4FE3-95EB-4308A6511664}\ifc * Database version: 5507 * Database creation date: Tue Apr 23 19:00:08 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Apr 23 19:00:08 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Apr 23 19:00:08 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2022
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2022
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее(Type) - Категория: Уровни; Имя семейства: Уровень
Зависимости - Фасад: 0 mm
Идентификация - Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Прочее - Категория: Уровни; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Размеры - Расчетная высота: 0 mm
Графика(Type) - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: Сплошная; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Зависимости(Type) - Базовая отметка: Базовая точка проекта
Идентификация(Type) - Имя типа: Отметка уровня с именем

# IfcBuildingElementProxy: EOS Storage 358 В/280 Ач/100.3 кВтч, EOS_Шкафной-LFP_НакопительЭлектроэнергии_EOS-Storage_НапольноеИсполнение_358В_280Ач_DKC:EOS Storage 358 В/280 Ач/100.3 кВтч:625060
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Решетка-Соты_Черный
Type - Данные - ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: ESE358C280E; ADSK_Количество: 1; ADSK_Марка: EOS Storage; ADSK_Масса: 1100; ADSK_Масса_Текст: 1100; ADSK_Материал: DKC_Корпус_Черный; ADSK_Наименование: Шкафной LFP накопитель энергии EOS Storage 358 В/280 Ач/100.3 кВтч; ADSK_Наименование краткое: EOS Storage 358 В/280 Ач/100.3 кВтч
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/53b/o9ndiqpxaocwxvlh41tymhyg6p61rx0q.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1819/ESE358C280E/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Storage 358 В/280 Ач/100.3 кВтч; Описание: Литий-железо-фосфатные (LiFePO4, LFP) аккумуляторы и высоковольтные накопительные сборки со встроенной системой мониторинга (BMS) ячеек А-класса служат для резервного хранения электроэнергии и создания независимых систем электроснабжения потребителей на базе солнечных инверторов и ДГУ там, где это необходимо в силу отсутствия привычных электросетей питания. Также они могут применяться в автономном транспорте, например, в автодомах, электролодках, яхтах, мотоциклах и т.п.
Type - Материалы и отделка - Материал_Зона обслуживания: DKC_Зона обслуживания; Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001757; Имя семейства: EOS_Шкафной-LFP_НакопительЭлектроэнергии_EOS-Storage_НапольноеИсполнение_358В_280Ач_DKC; Интерфейсы связи: CAN/RS232/RS485; Номинальная емкость: 280 Ач; Рабочая температура: 0°С ~ 55°С; Степень защиты: IP 21; Энергоемкость: 100,3 кВтч
Type - Размеры - ADSK_Размер_Высота: 1870 mm; ADSK_Размер_Глубина: 1000 mm; ADSK_Размер_Ширина: 1200 mm
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Коэффициент мощности: 1; ADSK_Напряжение: 358.4 V; ADSK_Номинальная мощность: 100300 W; ADSK_Полная мощность: 100300 W; ADSK_Ток: 140 A
Pset_BuildingElementProxyCommon - Reference: EOS Storage 358 В/280 Ач/100.3 кВтч
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - ADSK_Зона обслуживания: yes
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 119
Прочее - Код типа: EOS_Шкафной-LFP_НакопительЭлектроэнергии_EOS-Storage_НапольноеИсполнение_358В_280Ач_DKC: EOS Storage 358 В/280 Ач/100.3 кВтч; Семейство: EOS_Шкафной-LFP_НакопительЭлектроэнергии_EOS-Storage_НапольноеИсполнение_358В_280Ач_DKC: EOS Storage 358 В/280 Ач/100.3 кВтч; Семейство и типоразмер: EOS_Шкафной-LFP_НакопительЭлектроэнергии_EOS-Storage_НапольноеИсполнение_358В_280Ач_DKC: EOS Storage 358 В/280 Ач/100.3 кВтч; Тип: EOS_Шкафной-LFP_НакопительЭлектроэнергии_EOS-Storage_НапольноеИсполнение_358В_280Ач_DKC: EOS Storage 358 В/280 Ач/100.3 кВтч
Размеры - Объем: 7.6296 m3; Площадь: 17.17 m2
Свойства модели - Размер_Глубина ЗО: 1200 mm
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 358 В/3-100300 В·А

# IfcBuildingElementProxy: Текст модели:75 мм Arial
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 75 мм Arial
Графика - Горизонтальное выравнивание: По центру; Текст: 358 В/280 Ач/ 100.3 кВтч
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Вариант конструкции: Оформление каталога (основной); Подкатегория: Обобщенные модели
Материалы и отделка - Материал: DKC_СерыйЛого
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 75 мм Arial; Семейство: Текст модели: 75 мм Arial; Семейство и типоразмер: Текст модели: 75 мм Arial; Тип: Текст модели: 75 мм Arial
Размеры - Глубина:: 5 mm
Стадии - Стадия возведения: Стадия 1
Идентификация(Type) - Имя типа: 75 мм Arial
Прочее(Type) - Категория: Обобщенные модели; Имя семейства: Текст модели
Текст(Type) - Жирный: no; Курсив: no; Размер текста: 75 mm; Шрифт текста: Arial
