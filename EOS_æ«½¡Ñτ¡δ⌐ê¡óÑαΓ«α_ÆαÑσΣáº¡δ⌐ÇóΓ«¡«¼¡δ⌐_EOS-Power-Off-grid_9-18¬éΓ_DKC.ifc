Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-04-23T18:56:42
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181217_1515(x64) - Exporter 19.2.0.65 - Альтернативный интерфейс 19.2.0.65
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Apr 23 18:56:42 2024 * Host: WIN-0P1AU7TJQME * Database: C:\Users\user\AppData\Local\Temp\{22B706BF-6DE1-4197-B88F-3AE7D0047F54}\ifc * Database version: 5507 * Database creation date: Tue Apr 23 18:56:42 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Apr 23 18:56:42 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Apr 23 18:56:42 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2022
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2022
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее(Type) - Категория: Уровни; Имя семейства: Уровень
Идентификация(Type) - Имя типа: Отметка уровня с именем
Зависимости(Type) - Базовая отметка: Базовая точка проекта
Графика(Type) - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: Сплошная; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Зависимости - Фасад: 0 mm
Идентификация - Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Прочее - Категория: Уровни; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: EOS Power Off-grid 18 кВт/1MPPT, EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_9-18кВт_DKC:EOS Power Off-grid 18 кВт/1MPPT:625032
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Корпус_Светло-серый, DKC_Решетка-Соты_Черный
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPA025D018A; ADSK_Марка: EOS Power Off-grid; ADSK_Масса: 223; ADSK_Масса_Текст: 223; ADSK_Наименование: Трехфазный солнечный инвертор EOS Power Off-grid 18 кВт/1MPPT; ADSK_Наименование краткое: Инвертор EOS Power Off-grid 18 кВт/1MPPT
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/8fc/36yu034fcwucv0w4ajk8m9breisc3ta6.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1759/EPA025D018A/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power Off-grid 18 кВт/1MPPT; Описание: Автономные солнечные инверторы используются для создания систем независимого электроснабжения потребителей там, где это необходимо: в доме, коттедже, предприятии и т.д. Аккумулируя и пропуская через инвертор солнечную энергию, вырабатываемую фотоэлектрическими панелями, а также энергию от дополнительных источников питания - сети и дизель-генератора - можно предоставлять эту энергию по мере необходимости потребителям, обеспечивать стабильное штатное и аварийное их питание.
Type - Материалы и отделка - Материал_Зона обслуживания: DKC_Зона обслуживания; Материал_Логотип: DKC_Корпус_Красный; Материал_Панель управления: DKC_Корпус_Черный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_9-18кВт_DKC; Интерфейсы связи: RS232/RS485/USB/реле (базовые); SNMP/Wi-Fi/GPRS (опция); Рабочая температура: 0°С ~ 40°С; Степень защиты: IP 20
Type - Размеры - ADSK_Размер_Высота: 1100 mm; ADSK_Размер_Глубина: 840 mm; ADSK_Размер_Ширина: 450 mm
Type - Электросети - Номинальное напряжение АКБ: 360 V; Полная мощность АКБ: 0 W
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Коэффициент мощности: 0.9; ADSK_КПД: 91; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 18000 W; ADSK_Полная мощность: 20000 W; ADSK_Ток: 60 A
Pset_BuildingElementProxyCommon - Reference: EOS Power Off-grid 18 кВт/1MPPT
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - ADSK_Зона обслуживания: yes
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 46
Прочее - Код типа: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_9-18кВт_DKC: EOS Power Off-grid 18 кВт/1MPPT; Семейство: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_9-18кВт_DKC: EOS Power Off-grid 18 кВт/1MPPT; Семейство и типоразмер: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_9-18кВт_DKC: EOS Power Off-grid 18 кВт/1MPPT; Тип: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_9-18кВт_DKC: EOS Power Off-grid 18 кВт/1MPPT
Размеры - Объем: 0.919786 m3; Площадь: 4.37346 m2
Свойства модели - Размер_Глубина ЗО: 500 mm
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-20000 В·А-Подключение АКБ 360 В/3-0 В·А

# IfcBuildingElementProxy: EOS Power Off-grid 18 кВт/2MPPT, EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_9-18кВт_DKC:EOS Power Off-grid 18 кВт/2MPPT:625033
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Корпус_Светло-серый, DKC_Решетка-Соты_Черный
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPA050D018A; ADSK_Марка: EOS Power Off-grid; ADSK_Масса: 229; ADSK_Масса_Текст: 229; ADSK_Наименование: Трехфазный солнечный инвертор EOS Power Off-grid 18 кВт/2MPPT; ADSK_Наименование краткое: Инвертор EOS Power Off-grid 18 кВт/2MPPT
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/8fc/36yu034fcwucv0w4ajk8m9breisc3ta6.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1759/EPA050D018A/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power Off-grid 18 кВт/2MPPT; Описание: Автономные солнечные инверторы используются для создания систем независимого электроснабжения потребителей там, где это необходимо: в доме, коттедже, предприятии и т.д. Аккумулируя и пропуская через инвертор солнечную энергию, вырабатываемую фотоэлектрическими панелями, а также энергию от дополнительных источников питания - сети и дизель-генератора - можно предоставлять эту энергию по мере необходимости потребителям, обеспечивать стабильное штатное и аварийное их питание.
Type - Материалы и отделка - Материал_Зона обслуживания: DKC_Зона обслуживания; Материал_Логотип: DKC_Корпус_Красный; Материал_Панель управления: DKC_Корпус_Черный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_9-18кВт_DKC; Интерфейсы связи: RS232/RS485/USB/реле (базовые); SNMP/Wi-Fi/GPRS (опция); Рабочая температура: 0°С ~ 40°С; Степень защиты: IP 20
Type - Размеры - ADSK_Размер_Высота: 1100 mm; ADSK_Размер_Глубина: 840 mm; ADSK_Размер_Ширина: 450 mm
Type - Электросети - Номинальное напряжение АКБ: 360 V; Полная мощность АКБ: 0 W
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Коэффициент мощности: 0.9; ADSK_КПД: 91; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 18000 W; ADSK_Полная мощность: 20000 W; ADSK_Ток: 120 A
Pset_BuildingElementProxyCommon - Reference: EOS Power Off-grid 18 кВт/2MPPT
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - ADSK_Зона обслуживания: yes
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 47
Прочее - Код типа: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_9-18кВт_DKC: EOS Power Off-grid 18 кВт/2MPPT; Семейство: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_9-18кВт_DKC: EOS Power Off-grid 18 кВт/2MPPT; Семейство и типоразмер: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_9-18кВт_DKC: EOS Power Off-grid 18 кВт/2MPPT; Тип: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_9-18кВт_DKC: EOS Power Off-grid 18 кВт/2MPPT
Размеры - Объем: 0.919786 m3; Площадь: 4.37346 m2
Свойства модели - Размер_Глубина ЗО: 500 mm
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-20000 В·А-Подключение АКБ 360 В/3-0 В·А

# IfcBuildingElementProxy: EOS Power Off-grid 9 кВт/1MPPT, EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_9-18кВт_DKC:EOS Power Off-grid 9 кВт/1MPPT:625030
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Корпус_Светло-серый, DKC_Решетка-Соты_Черный
Type - Данные - ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPA025D009A; ADSK_Количество: 1; ADSK_Марка: EOS Power Off-grid; ADSK_Масса: 210; ADSK_Масса_Текст: 210; ADSK_Материал: DKC_Корпус_Черный; ADSK_Наименование: Трехфазный солнечный инвертор EOS Power Off-grid 9 кВт/1MPPT; ADSK_Наименование краткое: Инвертор EOS Power Off-grid 9 кВт/1MPPT
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/8fc/36yu034fcwucv0w4ajk8m9breisc3ta6.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1759/EPA025D009A/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power Off-grid 9 кВт/1MPPT; Описание: Автономные солнечные инверторы используются для создания систем независимого электроснабжения потребителей там, где это необходимо: в доме, коттедже, предприятии и т.д. Аккумулируя и пропуская через инвертор солнечную энергию, вырабатываемую фотоэлектрическими панелями, а также энергию от дополнительных источников питания - сети и дизель-генератора - можно предоставлять эту энергию по мере необходимости потребителям, обеспечивать стабильное штатное и аварийное их питание.
Type - Материалы и отделка - Материал_Зона обслуживания: DKC_Зона обслуживания; Материал_Логотип: DKC_Корпус_Красный; Материал_Панель управления: DKC_Корпус_Черный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_9-18кВт_DKC; Интерфейсы связи: RS232/RS485/USB/реле (базовые); SNMP/Wi-Fi/GPRS (опция); Рабочая температура: 0°С ~ 40°С; Степень защиты: IP 20
Type - Размеры - ADSK_Размер_Высота: 1100 mm; ADSK_Размер_Глубина: 840 mm; ADSK_Размер_Ширина: 450 mm
Type - Электросети - Номинальное напряжение АКБ: 360 V; Полная мощность АКБ: 0 W
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Коэффициент мощности: 0.9; ADSK_КПД: 91; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 9000 W; ADSK_Полная мощность: 10000 W; ADSK_Ток: 60 A
Pset_BuildingElementProxyCommon - Reference: EOS Power Off-grid 9 кВт/1MPPT
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - ADSK_Зона обслуживания: yes
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 44
Прочее - Код типа: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_9-18кВт_DKC: EOS Power Off-grid 9 кВт/1MPPT; Семейство: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_9-18кВт_DKC: EOS Power Off-grid 9 кВт/1MPPT; Семейство и типоразмер: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_9-18кВт_DKC: EOS Power Off-grid 9 кВт/1MPPT; Тип: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_9-18кВт_DKC: EOS Power Off-grid 9 кВт/1MPPT
Размеры - Объем: 0.919786 m3; Площадь: 4.37346 m2
Свойства модели - Размер_Глубина ЗО: 500 mm
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-10000 В·А-Подключение АКБ 360 В/3-0 В·А

# IfcBuildingElementProxy: EOS Power Off-grid 9 кВт/2MPPT, EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_9-18кВт_DKC:EOS Power Off-grid 9 кВт/2MPPT:625031
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Корпус_Светло-серый, DKC_Решетка-Соты_Черный
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPA050D009A; ADSK_Марка: EOS Power Off-grid; ADSK_Масса: 216; ADSK_Масса_Текст: 216; ADSK_Наименование: Трехфазный солнечный инвертор EOS Power Off-grid 9 кВт/2MPPT; ADSK_Наименование краткое: Инвертор EOS Power Off-grid 9 кВт/2MPPT
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/8fc/36yu034fcwucv0w4ajk8m9breisc3ta6.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1759/EPA050D009A/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power Off-grid 9 кВт/2MPPT; Описание: Автономные солнечные инверторы используются для создания систем независимого электроснабжения потребителей там, где это необходимо: в доме, коттедже, предприятии и т.д. Аккумулируя и пропуская через инвертор солнечную энергию, вырабатываемую фотоэлектрическими панелями, а также энергию от дополнительных источников питания - сети и дизель-генератора - можно предоставлять эту энергию по мере необходимости потребителям, обеспечивать стабильное штатное и аварийное их питание.
Type - Материалы и отделка - Материал_Зона обслуживания: DKC_Зона обслуживания; Материал_Логотип: DKC_Корпус_Красный; Материал_Панель управления: DKC_Корпус_Черный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_9-18кВт_DKC; Интерфейсы связи: RS232/RS485/USB/реле (базовые); SNMP/Wi-Fi/GPRS (опция); Рабочая температура: 0°С ~ 40°С; Степень защиты: IP 20
Type - Размеры - ADSK_Размер_Высота: 1100 mm; ADSK_Размер_Глубина: 840 mm; ADSK_Размер_Ширина: 450 mm
Type - Электросети - Номинальное напряжение АКБ: 360 V; Полная мощность АКБ: 0 W
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Коэффициент мощности: 0.9; ADSK_КПД: 91; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 9000 W; ADSK_Полная мощность: 10000 W; ADSK_Ток: 120 A
Pset_BuildingElementProxyCommon - Reference: EOS Power Off-grid 9 кВт/2MPPT
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - ADSK_Зона обслуживания: yes
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 45
Прочее - Код типа: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_9-18кВт_DKC: EOS Power Off-grid 9 кВт/2MPPT; Семейство: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_9-18кВт_DKC: EOS Power Off-grid 9 кВт/2MPPT; Семейство и типоразмер: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_9-18кВт_DKC: EOS Power Off-grid 9 кВт/2MPPT; Тип: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_9-18кВт_DKC: EOS Power Off-grid 9 кВт/2MPPT
Размеры - Объем: 0.919786 m3; Площадь: 4.37346 m2
Свойства модели - Размер_Глубина ЗО: 500 mm
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-10000 В·А-Подключение АКБ 360 В/3-0 В·А

# IfcBuildingElementProxy: Текст модели:75 мм Arial (4)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 75 мм Arial
Графика - Горизонтальное выравнивание: По центру
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели
Материалы и отделка - Материал: DKC_СерыйЛого
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 75 мм Arial; Семейство: Текст модели: 75 мм Arial; Семейство и типоразмер: Текст модели: 75 мм Arial; Тип: Текст модели: 75 мм Arial
Размеры - Глубина:: 5 mm
Стадии - Стадия возведения: Стадия 1
Идентификация(Type) - Имя типа: 75 мм Arial
Прочее(Type) - Категория: Обобщенные модели; Имя семейства: Текст модели
Текст(Type) - Жирный: no; Курсив: no; Размер текста: 75 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст | Вариант конструкции
75 мм Arial | 9 кВт/ 1MPPT | Оформление каталога (основной)
75 мм Arial | 9 кВт/ 2MPPT | Оформление каталога : Оформление каталога
75 мм Arial | 18 кВт/ 1MPPT | Оформление каталога : Оформление каталога
75 мм Arial | 18 кВт/ 2MPPT | Оформление каталога : Оформление каталога
