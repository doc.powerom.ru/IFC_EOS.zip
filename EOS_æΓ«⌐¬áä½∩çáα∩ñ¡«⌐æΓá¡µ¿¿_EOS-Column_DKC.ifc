Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-04-23T19:08:06
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181217_1515(x64) - Exporter 19.2.0.65 - Альтернативный интерфейс 19.2.0.65
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Apr 23 19:08:06 2024 * Host: WIN-0P1AU7TJQME * Database: C:\Users\user\AppData\Local\Temp\{E0627A28-B1DF-4993-943D-945C19A03700}\ifc * Database version: 5507 * Database creation date: Tue Apr 23 19:08:06 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Apr 23 19:08:06 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Apr 23 19:08:06 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2022
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2022
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее(Type) - Категория: Уровни; Имя семейства: Уровень
Идентификация(Type) - Имя типа: Отметка уровня с именем
Зависимости - Фасад: 0 mm
Идентификация - Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Прочее - Категория: Уровни; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Размеры - Расчетная высота: 0 mm
Графика(Type) - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: Сплошная; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Зависимости(Type) - Базовая отметка: Базовая точка проекта

# IfcBuildingElementProxy: Стойка для двух зарядных станций "EOS Charge", EOS_СтойкаДляЗаряднойСтанции_EOS-Column_DKC:Стойка для двух зарядных станций "EOS Charge":625078
In: Этаж 01
Type - Material: DKC_Корпус_Черный, DKC_Корпус_Красный
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: ECCOLUMN2; ADSK_Марка: EOS Сolumn; ADSK_Масса: 23.5; ADSK_Масса_Текст: 23.5; ADSK_Наименование: Стойка для двух зарядных станций "EOS Charge"; ADSK_Наименование краткое: Стойка EOS СOLUMN2
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/zaryadnye-stantsii-peremennogo-toka-dlya-elektromobiley-eos-charge/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1659/ECCOLUMN1/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: Стойка для двух зарядных станций "EOS Charge"; Описание: Стойки для зарядной станции EOS Column предназначены для установки на нее зарядной станции переменного тока EOS Charge для заряда аккумуляторов электротранспорта.
Type - Материалы и отделка - Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001941; Видимость_Крепление для 2-й зарядной станции: yes; Имя семейства: EOS_СтойкаДляЗаряднойСтанции_EOS-Column_DKC
Type - Размеры - ADSK_Размер_Высота: 1507.5 mm; ADSK_Размер_Глубина: 200 mm; ADSK_Размер_Ширина: 361 mm
Pset_BuildingElementProxyCommon - Reference: Стойка для двух зарядных станций "EOS Charge"
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Перемещать с соседними элементами: no; Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 156
Прочее - Код типа: EOS_СтойкаДляЗаряднойСтанции_EOS-Column_DKC: Стойка для двух зарядных станций "EOS Charge"; Семейство: EOS_СтойкаДляЗаряднойСтанции_EOS-Column_DKC: Стойка для двух зарядных станций "EOS Charge"; Семейство и типоразмер: EOS_СтойкаДляЗаряднойСтанции_EOS-Column_DKC: Стойка для двух зарядных станций "EOS Charge"; Тип: EOS_СтойкаДляЗаряднойСтанции_EOS-Column_DKC: Стойка для двух зарядных станций "EOS Charge"
Размеры - Объем: 0.108842 m3; Площадь: 0.917908 m2
Стадии - Стадия возведения: Стадия 1

# IfcBuildingElementProxy: Стойка для одной зарядной станции "EOS Charge", EOS_СтойкаДляЗаряднойСтанции_EOS-Column_DKC:Стойка для одной зарядной станции "EOS Charge":625077
In: Этаж 01
Type - Material: DKC_Корпус_Черный, DKC_Корпус_Красный
Type - Данные - ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: ECCOLUMN1; ADSK_Количество: 1; ADSK_Марка: EOS Сolumn; ADSK_Масса: 23.5; ADSK_Масса_Текст: 23.5; ADSK_Материал: DKC_Корпус_Черный; ADSK_Наименование: Стойка для одной зарядной станции "EOS Charge"; ADSK_Наименование краткое: Стойка EOS СOLUMN1
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/zaryadnye-stantsii-peremennogo-toka-dlya-elektromobiley-eos-charge/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1659/ECCOLUMN1/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: Стойка для одной зарядной станции "EOS Charge"; Описание: Стойки для зарядной станции EOS Column предназначены для установки на нее зарядной станции переменного тока EOS Charge для заряда аккумуляторов электротранспорта.
Type - Материалы и отделка - Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001941; Видимость_Крепление для 2-й зарядной станции: no; Имя семейства: EOS_СтойкаДляЗаряднойСтанции_EOS-Column_DKC
Type - Размеры - ADSK_Размер_Высота: 1507.5 mm; ADSK_Размер_Глубина: 200 mm; ADSK_Размер_Ширина: 361 mm
Pset_BuildingElementProxyCommon - Reference: Стойка для одной зарядной станции "EOS Charge"
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Основа: Уровень : Этаж 01; Перемещать с соседними элементами: no; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 155
Прочее - Код типа: EOS_СтойкаДляЗаряднойСтанции_EOS-Column_DKC: Стойка для одной зарядной станции "EOS Charge"; Семейство: EOS_СтойкаДляЗаряднойСтанции_EOS-Column_DKC: Стойка для одной зарядной станции "EOS Charge"; Семейство и типоразмер: EOS_СтойкаДляЗаряднойСтанции_EOS-Column_DKC: Стойка для одной зарядной станции "EOS Charge"; Тип: EOS_СтойкаДляЗаряднойСтанции_EOS-Column_DKC: Стойка для одной зарядной станции "EOS Charge"
Размеры - Объем: 0.108842 m3; Площадь: 0.917908 m2
Стадии - Стадия возведения: Стадия 1

# IfcBuildingElementProxy: Текст модели:75 мм Arial (2)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 75 мм Arial
Графика - Горизонтальное выравнивание: По центру
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Вариант конструкции: Оформление каталога : Оформление каталога; Подкатегория: Обобщенные модели
Материалы и отделка - Материал: DKC_СерыйЛого
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 75 мм Arial; Семейство: Текст модели: 75 мм Arial; Семейство и типоразмер: Текст модели: 75 мм Arial; Тип: Текст модели: 75 мм Arial
Размеры - Глубина:: 5 mm
Стадии - Стадия возведения: Стадия 1
Идентификация(Type) - Имя типа: 75 мм Arial
Прочее(Type) - Категория: Обобщенные модели; Имя семейства: Текст модели
Текст(Type) - Жирный: no; Курсив: no; Размер текста: 75 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст
75 мм Arial | 1 станция
75 мм Arial | 2 станции
