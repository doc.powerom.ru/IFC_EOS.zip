Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-04-23T19:09:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181217_1515(x64) - Exporter 19.2.0.65 - Альтернативный интерфейс 19.2.0.65
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Apr 23 19:09:37 2024 * Host: WIN-0P1AU7TJQME * Database: C:\Users\user\AppData\Local\Temp\{07EF6E82-CFED-4F39-BEC6-8853914DEAC9}\ifc * Database version: 5507 * Database creation date: Tue Apr 23 19:09:36 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Apr 23 19:09:36 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Apr 23 19:09:36 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2022
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2022
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее(Type) - Категория: Уровни; Имя семейства: Уровень
Идентификация(Type) - Имя типа: Отметка уровня с именем
Зависимости - Фасад: 0 mm
Идентификация - Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Прочее - Категория: Уровни; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Размеры - Расчетная высота: 0 mm
Графика(Type) - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: Сплошная; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Зависимости(Type) - Базовая отметка: Базовая точка проекта

# IfcBuildingElementProxy: EOS Storage 25 В/50 Ач/1.28 кВтч, настенный, EOS_LFP_НакопительЭлектроэнергии_EOS-Storage_НастенноеИсполнение_25-51В_50-67Ач_DKC:EOS Storage 25 В/50 Ач/1.28 кВтч, настенный:625056
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Белый, DKC_Корпус_Светло-серый, DKC_Корпус_Синий, DKC_Корпус_Черный, DKC_Корпус_Оранжевый
Type - Данные - ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: ESS025W050E; ADSK_Количество: 1; ADSK_Марка: EOS Storage; ADSK_Масса: 19; ADSK_Масса_Текст: 19; ADSK_Материал: DKC_Корпус_Белый; ADSK_Наименование: LFP накопитель эл.энергии EOS Storage 25 В/50 Ач/1.28 кВтч, настенный; ADSK_Наименование краткое: EOS Storage 25 В/50 Ач/1.28 кВтч, настенный
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/4ae/87vjti41bg0qyjtcwuxto7g5ys5x1lwq.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1819/ESS025W050E/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Storage 25 В/50 Ач/1.28 кВтч, настенный; Описание: Литий-железо-фосфатные (LiFePO4, LFP) аккумуляторы и высоковольтные накопительные сборки со встроенной системой мониторинга (BMS) ячеек А-класса служат для резервного хранения электроэнергии и создания независимых систем электроснабжения потребителей на базе солнечных инверторов и ДГУ там, где это необходимо в силу отсутствия привычных электросетей питания. Также они могут применяться в автономном транспорте, например, в автодомах, электролодках, яхтах, мотоциклах и т.п.
Type - Материалы и отделка - Материал_Дисплей: DKC_Корпус_Черный; Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001757; Имя семейства: EOS_LFP_НакопительЭлектроэнергии_EOS-Storage_НастенноеИсполнение_25-51В_50-67Ач_DKC; Интерфейсы связи: CAN/RS232/RS485; Номинальная емкость: 50 Ач; Рабочая температура: 0°С ~ 55°С; Степень защиты: IP 54; Энергоемкость: 1,28 кВтч
Type - Размеры - ADSK_Размер_Высота: 400 mm; ADSK_Размер_Глубина: 170 mm; ADSK_Размер_Ширина: 255 mm; Размер_Дисплей_Высота: 90.7518 mm; Размер_Крепление_Глубина: 19.2635 mm; Размер_Крепление_Отступ: 63.7071 mm; Размер_Крепление_Сверху: 48 mm; Размер_Крепление_Снизу: 72 mm; Размер_Основание_Отступ: 25.0182 mm; Размер_Подключение_В центре: 22.5 mm; Размер_Подключение_Глубина: 42.041 mm; Размер_Подключение_По бокам: 67.5 mm; Размер_Рукоятки_Высота: 82.5 mm
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 1; ADSK_Количество фаз числовое: 1; ADSK_Коэффициент мощности: 1; ADSK_Напряжение: 25.6 V; ADSK_Номинальная мощность: 1280 W; ADSK_Полная мощность: 1280 W; ADSK_Ток: 50 A
Pset_BuildingElementProxyCommon - Reference: EOS Storage 25 В/50 Ач/1.28 кВтч, настенный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Марка: 109
Прочее - Код типа: EOS_LFP_НакопительЭлектроэнергии_EOS-Storage_НастенноеИсполнение_25-51В_50-67Ач_DKC: EOS Storage 25 В/50 Ач/1.28 кВтч, настенный; Семейство: EOS_LFP_НакопительЭлектроэнергии_EOS-Storage_НастенноеИсполнение_25-51В_50-67Ач_DKC: EOS Storage 25 В/50 Ач/1.28 кВтч, настенный; Семейство и типоразмер: EOS_LFP_НакопительЭлектроэнергии_EOS-Storage_НастенноеИсполнение_25-51В_50-67Ач_DKC: EOS Storage 25 В/50 Ач/1.28 кВтч, настенный; Тип: EOS_LFP_НакопительЭлектроэнергии_EOS-Storage_НастенноеИсполнение_25-51В_50-67Ач_DKC: EOS Storage 25 В/50 Ач/1.28 кВтч, настенный
Размеры - Объем: 0.0193049 m3; Площадь: 0.225968 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 26 В/1-1280 В·А

# IfcBuildingElementProxy: EOS Storage 51 В/67 Ач/3.43 кВтч, настенный, EOS_LFP_НакопительЭлектроэнергии_EOS-Storage_НастенноеИсполнение_25-51В_50-67Ач_DKC:EOS Storage 51 В/67 Ач/3.43 кВтч, настенный:625057
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Белый, DKC_Корпус_Светло-серый, DKC_Корпус_Синий, DKC_Корпус_Черный, DKC_Корпус_Оранжевый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Белый; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: ESS051W067E; ADSK_Марка: EOS Storage; ADSK_Масса: 34; ADSK_Масса_Текст: 34; ADSK_Наименование: LFP накопитель эл.энергии EOS Storage 51 В/67 Ач/3.43 кВтч, настенный; ADSK_Наименование краткое: EOS Storage 51 В/67 Ач/3.43 кВтч, настенный
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/4ae/87vjti41bg0qyjtcwuxto7g5ys5x1lwq.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1819/ESS051W067E/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Storage 51 В/67 Ач/3.43 кВтч, настенный; Описание: Литий-железо-фосфатные (LiFePO4, LFP) аккумуляторы и высоковольтные накопительные сборки со встроенной системой мониторинга (BMS) ячеек А-класса служат для резервного хранения электроэнергии и создания независимых систем электроснабжения потребителей на базе солнечных инверторов и ДГУ там, где это необходимо в силу отсутствия привычных электросетей питания. Также они могут применяться в автономном транспорте, например, в автодомах, электролодках, яхтах, мотоциклах и т.п.
Type - Материалы и отделка - Материал_Дисплей: DKC_Корпус_Черный; Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001757; Имя семейства: EOS_LFP_НакопительЭлектроэнергии_EOS-Storage_НастенноеИсполнение_25-51В_50-67Ач_DKC; Интерфейсы связи: CAN/RS232/RS485; Номинальная емкость: 67; Рабочая температура: 0°С ~ 55°С; Степень защиты: IP 54; Энергоемкость: 3,43 кВтч
Type - Размеры - ADSK_Размер_Высота: 460 mm; ADSK_Размер_Глубина: 180 mm; ADSK_Размер_Ширина: 290 mm; Размер_Дисплей_Высота: 120 mm; Размер_Крепление_Глубина: 19.2635 mm; Размер_Крепление_Отступ: 83 mm; Размер_Крепление_Сверху: 34 mm; Размер_Крепление_Снизу: 46 mm; Размер_Основание_Отступ: 28.5 mm; Размер_Подключение_В центре: 30 mm; Размер_Подключение_Глубина: 53.549 mm; Размер_Подключение_По бокам: 75 mm; Размер_Рукоятки_Высота: 78.5 mm
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 1; ADSK_Количество фаз числовое: 1; ADSK_Коэффициент мощности: 1; ADSK_Напряжение: 51.2 V; ADSK_Номинальная мощность: 3430 W; ADSK_Полная мощность: 3430 W; ADSK_Ток: 67 A
Pset_BuildingElementProxyCommon - Reference: EOS Storage 51 В/67 Ач/3.43 кВтч, настенный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 110
Прочее - Код типа: EOS_LFP_НакопительЭлектроэнергии_EOS-Storage_НастенноеИсполнение_25-51В_50-67Ач_DKC: EOS Storage 51 В/67 Ач/3.43 кВтч, настенный; Семейство: EOS_LFP_НакопительЭлектроэнергии_EOS-Storage_НастенноеИсполнение_25-51В_50-67Ач_DKC: EOS Storage 51 В/67 Ач/3.43 кВтч, настенный; Семейство и типоразмер: EOS_LFP_НакопительЭлектроэнергии_EOS-Storage_НастенноеИсполнение_25-51В_50-67Ач_DKC: EOS Storage 51 В/67 Ач/3.43 кВтч, настенный; Тип: EOS_LFP_НакопительЭлектроэнергии_EOS-Storage_НастенноеИсполнение_25-51В_50-67Ач_DKC: EOS Storage 51 В/67 Ач/3.43 кВтч, настенный
Размеры - Объем: 0.0265817 m3; Площадь: 0.282848 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 51 В/1-3430 В·А

# IfcBuildingElementProxy: Текст модели:75 мм Arial (2)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 75 мм Arial
Графика - Горизонтальное выравнивание: По центру
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Вариант конструкции: Оформление каталога : Оформление каталога; Подкатегория: Обобщенные модели
Материалы и отделка - Материал: DKC_СерыйЛого
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 75 мм Arial; Семейство: Текст модели: 75 мм Arial; Семейство и типоразмер: Текст модели: 75 мм Arial; Тип: Текст модели: 75 мм Arial
Размеры - Глубина:: 5 mm
Стадии - Стадия возведения: Стадия 1
Идентификация(Type) - Имя типа: 75 мм Arial
Прочее(Type) - Категория: Обобщенные модели; Имя семейства: Текст модели
Текст(Type) - Жирный: no; Курсив: no; Размер текста: 75 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст
75 мм Arial | 25 В/50 Ач/1.28 кВтч, настенный
75 мм Arial | 51 В/67 Ач/3.43 кВтч, настенный
