Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-04-23T19:08:43
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181217_1515(x64) - Exporter 19.2.0.65 - Альтернативный интерфейс 19.2.0.65
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Apr 23 19:08:43 2024 * Host: WIN-0P1AU7TJQME * Database: C:\Users\user\AppData\Local\Temp\{A8BB6243-7C95-4EF4-93EE-13FE2E6C9DD7}\ifc * Database version: 5507 * Database creation date: Tue Apr 23 19:08:43 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Apr 23 19:08:43 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Apr 23 19:08:43 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2022
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2022
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее(Type) - Категория: Уровни; Имя семейства: Уровень
Идентификация(Type) - Имя типа: Отметка уровня с именем
Зависимости - Фасад: 0 mm
Идентификация - Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Прочее - Категория: Уровни; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Размеры - Расчетная высота: 0 mm
Графика(Type) - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: Сплошная; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Зависимости(Type) - Базовая отметка: Базовая точка проекта

# IfcBuildingElementProxy: EOS Storage 25 В/50 Ач/1.28 кВтч, мет.корпус, EOS_LFP_НакопительЭлектроэнергии_EOS-Storage_ПолочноеИсполнение_25В_50Ач_DKC:EOS Storage 25 В/50 Ач/1.28 кВтч, мет.корпус:625055
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Корпус_Белый, DKC_Корпус_Светло-серый, DKC_Корпус_Оранжевый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: ESS025M050E; ADSK_Марка: EOS Storage; ADSK_Масса: 13; ADSK_Масса_Текст: 13; ADSK_Наименование: LFP накопитель эл.энергии EOS Storage 25 В/50 Ач/1.28 кВтч, мет.корпус; ADSK_Наименование краткое: EOS Storage 25 В/50 Ач/1.28 кВтч, мет.корпус
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/3f1/q6gnr28jo2qgt0ockwclod468z5vc0gl.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1819/ESS025M050E/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Storage 25 В/50 Ач/1.28 кВтч, мет.корпус; Описание: Литий-железо-фосфатные (LiFePO4, LFP) аккумуляторы и высоковольтные накопительные сборки со встроенной системой мониторинга (BMS) ячеек А-класса служат для резервного хранения электроэнергии и создания независимых систем электроснабжения потребителей на базе солнечных инверторов и ДГУ там, где это необходимо в силу отсутствия привычных электросетей питания. Также они могут применяться в автономном транспорте, например, в автодомах, электролодках, яхтах, мотоциклах и т.п.
Type - Материалы и отделка - Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001757; Имя семейства: EOS_LFP_НакопительЭлектроэнергии_EOS-Storage_ПолочноеИсполнение_25В_50Ач_DKC; Интерфейсы связи: -; Номинальная емкость: 50 Ач; Рабочая температура: 0°С ~ 55°С; Степень защиты: IP 54; Энергоемкость: 1,28 кВтч
Type - Размеры - ADSK_Размер_Высота: 175 mm; ADSK_Размер_Глубина: 155 mm; ADSK_Размер_Ширина: 350 mm; Размер_Корпус_Высота: 175 mm; Размер_Корпус_Дополнительный: 30 mm
Type - Стадии - Исполнение_Металл: yes; Исполнение_Пластик: no
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 1; ADSK_Количество фаз числовое: 1; ADSK_Коэффициент мощности: 1; ADSK_Напряжение: 25.6 V; ADSK_Номинальная мощность: 1280 W; ADSK_Полная мощность: 1280 W; ADSK_Ток: 50 A
Pset_BuildingElementProxyCommon - Reference: EOS Storage 25 В/50 Ач/1.28 кВтч, мет.корпус
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 106
Прочее - Код типа: EOS_LFP_НакопительЭлектроэнергии_EOS-Storage_ПолочноеИсполнение_25В_50Ач_DKC: EOS Storage 25 В/50 Ач/1.28 кВтч, мет.корпус; Семейство: EOS_LFP_НакопительЭлектроэнергии_EOS-Storage_ПолочноеИсполнение_25В_50Ач_DKC: EOS Storage 25 В/50 Ач/1.28 кВтч, мет.корпус; Семейство и типоразмер: EOS_LFP_НакопительЭлектроэнергии_EOS-Storage_ПолочноеИсполнение_25В_50Ач_DKC: EOS Storage 25 В/50 Ач/1.28 кВтч, мет.корпус; Тип: EOS_LFP_НакопительЭлектроэнергии_EOS-Storage_ПолочноеИсполнение_25В_50Ач_DKC: EOS Storage 25 В/50 Ач/1.28 кВтч, мет.корпус
Размеры - Объем: 0.00868 m3; Площадь: 0.132725 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 26 В/1-1280 В·А

# IfcBuildingElementProxy: EOS Storage 25 В/50 Ач/1.28 кВтч, пл.корпус, EOS_LFP_НакопительЭлектроэнергии_EOS-Storage_ПолочноеИсполнение_25В_50Ач_DKC:EOS Storage 25 В/50 Ач/1.28 кВтч, пл.корпус:625054
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Корпус_Белый
Type - Данные - ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: ESS025P050E; ADSK_Количество: 1; ADSK_Марка: EOS Storage; ADSK_Масса: 11; ADSK_Масса_Текст: 11; ADSK_Материал: DKC_Корпус_Черный; ADSK_Наименование: LFP накопитель эл.энергии EOS Storage 25 В/50 Ач/1.28 кВтч, пл.корпус; ADSK_Наименование краткое: EOS Storage 25 В/50 Ач/1.28 кВтч, пл.корпус
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/583/2t7no00easa0gpt82ziqpr9pb36bs28j.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1819/ESS025P050E/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Storage 25 В/50 Ач/1.28 кВтч, пл.корпус; Описание: Литий-железо-фосфатные (LiFePO4, LFP) аккумуляторы и высоковольтные накопительные сборки со встроенной системой мониторинга (BMS) ячеек А-класса служат для резервного хранения электроэнергии и создания независимых систем электроснабжения потребителей на базе солнечных инверторов и ДГУ там, где это необходимо в силу отсутствия привычных электросетей питания. Также они могут применяться в автономном транспорте, например, в автодомах, электролодках, яхтах, мотоциклах и т.п.
Type - Материалы и отделка - Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001757; Имя семейства: EOS_LFP_НакопительЭлектроэнергии_EOS-Storage_ПолочноеИсполнение_25В_50Ач_DKC; Интерфейсы связи: -; Номинальная емкость: 50 Ач; Рабочая температура: 0°С ~ 55°С; Степень защиты: IP 54; Энергоемкость: 1,28 кВтч
Type - Размеры - ADSK_Размер_Высота: 225 mm; ADSK_Размер_Глубина: 170 mm; ADSK_Размер_Ширина: 305 mm; Размер_Корпус_Высота: 212.2 mm; Размер_Корпус_Дополнительный: 0 mm
Type - Стадии - Исполнение_Металл: no; Исполнение_Пластик: yes
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 1; ADSK_Количество фаз числовое: 1; ADSK_Коэффициент мощности: 1; ADSK_Напряжение: 25.6 V; ADSK_Номинальная мощность: 1280 W; ADSK_Полная мощность: 1280 W; ADSK_Ток: 50 A
Pset_BuildingElementProxyCommon - Reference: EOS Storage 25 В/50 Ач/1.28 кВтч, пл.корпус
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Марка: 105
Прочее - Код типа: EOS_LFP_НакопительЭлектроэнергии_EOS-Storage_ПолочноеИсполнение_25В_50Ач_DKC: EOS Storage 25 В/50 Ач/1.28 кВтч, пл.корпус; Семейство: EOS_LFP_НакопительЭлектроэнергии_EOS-Storage_ПолочноеИсполнение_25В_50Ач_DKC: EOS Storage 25 В/50 Ач/1.28 кВтч, пл.корпус; Семейство и типоразмер: EOS_LFP_НакопительЭлектроэнергии_EOS-Storage_ПолочноеИсполнение_25В_50Ач_DKC: EOS Storage 25 В/50 Ач/1.28 кВтч, пл.корпус; Тип: EOS_LFP_НакопительЭлектроэнергии_EOS-Storage_ПолочноеИсполнение_25В_50Ач_DKC: EOS Storage 25 В/50 Ач/1.28 кВтч, пл.корпус
Размеры - Объем: 0.0110026 m3; Площадь: 0.152645 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 26 В/1-1280 В·А

# IfcBuildingElementProxy: Текст модели:75 мм Arial (2)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 75 мм Arial
Графика - Горизонтальное выравнивание: По центру
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Вариант конструкции: Оформление каталога (основной); Подкатегория: Обобщенные модели
Материалы и отделка - Материал: DKC_СерыйЛого
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 75 мм Arial; Семейство: Текст модели: 75 мм Arial; Семейство и типоразмер: Текст модели: 75 мм Arial; Тип: Текст модели: 75 мм Arial
Размеры - Глубина:: 5 mm
Стадии - Стадия возведения: Стадия 1
Идентификация(Type) - Имя типа: 75 мм Arial
Прочее(Type) - Категория: Обобщенные модели; Имя семейства: Текст модели
Текст(Type) - Жирный: no; Курсив: no; Размер текста: 75 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст
75 мм Arial | 25 В/50 Ач/1.28 кВтч, пл.корпус
75 мм Arial | 25 В/50 Ач/1.28 кВтч, мет.корпус
