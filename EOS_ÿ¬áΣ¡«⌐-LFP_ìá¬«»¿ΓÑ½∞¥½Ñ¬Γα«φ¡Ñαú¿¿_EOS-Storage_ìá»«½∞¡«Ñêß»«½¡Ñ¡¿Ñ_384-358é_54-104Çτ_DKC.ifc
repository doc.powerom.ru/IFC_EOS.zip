Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-04-23T18:59:09
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181217_1515(x64) - Exporter 19.2.0.65 - Альтернативный интерфейс 19.2.0.65
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Apr 23 18:59:09 2024 * Host: WIN-0P1AU7TJQME * Database: C:\Users\user\AppData\Local\Temp\{947C7770-BE1B-41B5-BD1B-EC5BB1CE0DBB}\ifc * Database version: 5507 * Database creation date: Tue Apr 23 18:59:08 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Apr 23 18:59:09 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Apr 23 18:59:09 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2022
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2022
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее(Type) - Категория: Уровни; Имя семейства: Уровень
Идентификация(Type) - Имя типа: Отметка уровня с именем
Зависимости - Фасад: 0 mm
Идентификация - Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Прочее - Категория: Уровни; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Размеры - Расчетная высота: 0 mm
Графика(Type) - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: Сплошная; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Зависимости(Type) - Базовая отметка: Базовая точка проекта

# IfcBuildingElementProxy: EOS Storage 358 В/104 Ач/37.2 кВтч, EOS_Шкафной-LFP_НакопительЭлектроэнергии_EOS-Storage_НапольноеИсполнение_384-358В_54-104Ач_DKC:EOS Storage 358 В/104 Ач/37.2 кВтч:625059
In: Этаж 01
Type - Material: DKC_Корпус_Черный, DKC_Корпус_Красный, DKC_Решетка-Соты_Черный
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: ESE358C104E; ADSK_Марка: EOS Storage; ADSK_Масса: 470; ADSK_Масса_Текст: 470; ADSK_Наименование: Шкафной LFP накопитель энергии EOS Storage 358 В/104 Ач/37.2 кВтч; ADSK_Наименование краткое: EOS Storage 358 В/104 Ач/37.2 кВтч
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/53b/o9ndiqpxaocwxvlh41tymhyg6p61rx0q.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1819/ESE358C104E/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Storage 358 В/104 Ач/37.2 кВтч; Описание: Литий-железо-фосфатные (LiFePO4, LFP) аккумуляторы и высоковольтные накопительные сборки со встроенной системой мониторинга (BMS) ячеек А-класса служат для резервного хранения электроэнергии и создания независимых систем электроснабжения потребителей на базе солнечных инверторов и ДГУ там, где это необходимо в силу отсутствия привычных электросетей питания. Также они могут применяться в автономном транспорте, например, в автодомах, электролодках, яхтах, мотоциклах и т.п.
Type - Материалы и отделка - Материал_Зона обслуживания: DKC_Зона обслуживания; Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001757; Имя семейства: EOS_Шкафной-LFP_НакопительЭлектроэнергии_EOS-Storage_НапольноеИсполнение_384-358В_54-104Ач_DKC; Интерфейсы связи: CAN/RS232/RS485; Номинальная емкость: 104 Ач; Рабочая температура: 0°С ~ 55°С; Степень защиты: IP 21; Энергоемкость: 37,27 кВтч
Type - Размеры - ADSK_Размер_Высота: 1800 mm; ADSK_Размер_Глубина: 650 mm; ADSK_Размер_Ширина: 600 mm
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Коэффициент мощности: 1; ADSK_Напряжение: 358.4 V; ADSK_Номинальная мощность: 37270 W; ADSK_Полная мощность: 37270 W; ADSK_Ток: 50 A
Pset_BuildingElementProxyCommon - Reference: EOS Storage 358 В/104 Ач/37.2 кВтч
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - ADSK_Зона обслуживания: yes
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 116
Прочее - Код типа: EOS_Шкафной-LFP_НакопительЭлектроэнергии_EOS-Storage_НапольноеИсполнение_384-358В_54-104Ач_DKC: EOS Storage 358 В/104 Ач/37.2 кВтч; Семейство: EOS_Шкафной-LFP_НакопительЭлектроэнергии_EOS-Storage_НапольноеИсполнение_384-358В_54-104Ач_DKC: EOS Storage 358 В/104 Ач/37.2 кВтч; Семейство и типоразмер: EOS_Шкафной-LFP_НакопительЭлектроэнергии_EOS-Storage_НапольноеИсполнение_384-358В_54-104Ач_DKC: EOS Storage 358 В/104 Ач/37.2 кВтч; Тип: EOS_Шкафной-LFP_НакопительЭлектроэнергии_EOS-Storage_НапольноеИсполнение_384-358В_54-104Ач_DKC: EOS Storage 358 В/104 Ач/37.2 кВтч
Размеры - Объем: 2.0021 m3; Площадь: 7.68912 m2
Свойства модели - Размер_Глубина ЗО: 600 mm
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 358 В/3-37270 В·А

# IfcBuildingElementProxy: EOS Storage 384 В/54 Ач/20.7 кВтч, EOS_Шкафной-LFP_НакопительЭлектроэнергии_EOS-Storage_НапольноеИсполнение_384-358В_54-104Ач_DKC:EOS Storage 384 В/54 Ач/20.7 кВтч:625058
In: Этаж 01
Type - Material: DKC_Корпус_Черный, DKC_Корпус_Красный, DKC_Решетка-Соты_Черный
Type - Данные - ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: ESE384C054E; ADSK_Количество: 1; ADSK_Марка: EOS Storage; ADSK_Масса: 370; ADSK_Масса_Текст: 370; ADSK_Материал: DKC_Корпус_Черный; ADSK_Наименование: Шкафной LFP накопитель энергии EOS Storage 384 В/54 Ач/20.7 кВтч; ADSK_Наименование краткое: EOS Storage 384 В/54 Ач/20.7 кВтч
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/53b/o9ndiqpxaocwxvlh41tymhyg6p61rx0q.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1819/ESE384C054E/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Storage 384 В/54 Ач/20.7 кВтч; Описание: Литий-железо-фосфатные (LiFePO4, LFP) аккумуляторы и высоковольтные накопительные сборки со встроенной системой мониторинга (BMS) ячеек А-класса служат для резервного хранения электроэнергии и создания независимых систем электроснабжения потребителей на базе солнечных инверторов и ДГУ там, где это необходимо в силу отсутствия привычных электросетей питания. Также они могут применяться в автономном транспорте, например, в автодомах, электролодках, яхтах, мотоциклах и т.п.
Type - Материалы и отделка - Материал_Зона обслуживания: DKC_Зона обслуживания; Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001757; Имя семейства: EOS_Шкафной-LFP_НакопительЭлектроэнергии_EOS-Storage_НапольноеИсполнение_384-358В_54-104Ач_DKC; Интерфейсы связи: CAN/RS232/RS485; Номинальная емкость: 54 Ач; Рабочая температура: 0°С ~ 55°С; Степень защиты: IP 21; Энергоемкость: 20,74 кВтч
Type - Размеры - ADSK_Размер_Высота: 1800 mm; ADSK_Размер_Глубина: 650 mm; ADSK_Размер_Ширина: 600 mm
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Коэффициент мощности: 1; ADSK_Напряжение: 384 V; ADSK_Номинальная мощность: 20740 W; ADSK_Полная мощность: 20740 W; ADSK_Ток: 27 A
Pset_BuildingElementProxyCommon - Reference: EOS Storage 384 В/54 Ач/20.7 кВтч
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - ADSK_Зона обслуживания: yes
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Марка: 115
Прочее - Код типа: EOS_Шкафной-LFP_НакопительЭлектроэнергии_EOS-Storage_НапольноеИсполнение_384-358В_54-104Ач_DKC: EOS Storage 384 В/54 Ач/20.7 кВтч; Семейство: EOS_Шкафной-LFP_НакопительЭлектроэнергии_EOS-Storage_НапольноеИсполнение_384-358В_54-104Ач_DKC: EOS Storage 384 В/54 Ач/20.7 кВтч; Семейство и типоразмер: EOS_Шкафной-LFP_НакопительЭлектроэнергии_EOS-Storage_НапольноеИсполнение_384-358В_54-104Ач_DKC: EOS Storage 384 В/54 Ач/20.7 кВтч; Тип: EOS_Шкафной-LFP_НакопительЭлектроэнергии_EOS-Storage_НапольноеИсполнение_384-358В_54-104Ач_DKC: EOS Storage 384 В/54 Ач/20.7 кВтч
Размеры - Объем: 2.0021 m3; Площадь: 7.68912 m2
Свойства модели - Размер_Глубина ЗО: 600 mm
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 384 В/3-20740 В·А

# IfcBuildingElementProxy: Текст модели:75 мм Arial (2)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 75 мм Arial
Графика - Горизонтальное выравнивание: По центру
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Вариант конструкции: Оформление каталога : Оформление каталога; Подкатегория: Обобщенные модели
Материалы и отделка - Материал: DKC_СерыйЛого
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 75 мм Arial; Семейство: Текст модели: 75 мм Arial; Семейство и типоразмер: Текст модели: 75 мм Arial; Тип: Текст модели: 75 мм Arial
Размеры - Глубина:: 5 mm
Стадии - Стадия возведения: Стадия 1
Идентификация(Type) - Имя типа: 75 мм Arial
Прочее(Type) - Категория: Обобщенные модели; Имя семейства: Текст модели
Текст(Type) - Жирный: no; Курсив: no; Размер текста: 75 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст
75 мм Arial | 384 В/54 Ач/ 20.7 кВтч
75 мм Arial | 358 В/104 Ач/ 37.2 кВтч
