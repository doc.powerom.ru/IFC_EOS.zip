Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-04-23T19:07:24
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181217_1515(x64) - Exporter 19.2.0.65 - Альтернативный интерфейс 19.2.0.65
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Apr 23 19:07:24 2024 * Host: WIN-0P1AU7TJQME * Database: C:\Users\user\AppData\Local\Temp\{92F5B72E-625D-4A1C-ABC9-2BAD528DA760}\ifc * Database version: 5507 * Database creation date: Tue Apr 23 19:07:21 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Apr 23 19:07:21 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Apr 23 19:07:21 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2022
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2022
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее(Type) - Категория: Уровни; Имя семейства: Уровень
Идентификация(Type) - Имя типа: Отметка уровня с именем
Зависимости(Type) - Базовая отметка: Базовая точка проекта
Графика(Type) - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: Сплошная; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Зависимости - Фасад: 0 mm
Идентификация - Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Прочее - Категория: Уровни; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN, EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC:EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN:625069
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Корпус_Серый, DKC_Корпус_Зеленый
Type - Данные - ADSK_Количество: 1; ADSK_Масса: 8; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EC22CCOMS; ADSK_Марка: EOS Charge; ADSK_Масса_Текст: 8; ADSK_Наименование: Зарядная станция переменного тока (AC) - EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN; ADSK_Наименование краткое: Инвертор EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/5f9/trggp66xrecvcamv0k10y73ros0lqtve.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1659/EC22CCOMS/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN; Описание: Зарядные станции ДКС подходят для частного и коммерческого использования. За вашу безопасность и защиту вашего электромобиля отвечают высококачественные компоненты европейского производства. Функция динамической балансировки нагрузки обеспечивает оптимальную зарядку электромобиля.
Type - Материалы и отделка - Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC002883; Защита от поражения электрическим током: Класс I; Имя семейства: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC; Интерфейсы связи: Wi-Fi-LAN/Ethernet (RJ-45); Класс защиты IK: IK10; Рабочая температура: -25°C ÷ +50°C; Степень защиты: IP 54
Type - Размеры - ADSK_Размер_Высота: 497 mm; ADSK_Размер_Глубина: 150 mm; ADSK_Размер_Ширина: 315 mm
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Коэффициент мощности: 1; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 22000 W; ADSK_Полная мощность: 22000 W; ADSK_Ток: 32 A
Pset_BuildingElementProxyCommon - Reference: EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 131
Прочее - Код типа: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN; Семейство: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN; Семейство и типоразмер: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN; Тип: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN
Размеры - Объем: 0.0234833 m3; Площадь: 0.278355 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-22000 В·А

# IfcBuildingElementProxy: EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN - MID, EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC:EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN - MID:625070
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Корпус_Серый, DKC_Корпус_Зеленый
Type - Данные - ADSK_Количество: 1; ADSK_Масса: 8; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EC22CMIDS; ADSK_Марка: EOS Charge; ADSK_Масса_Текст: 8; ADSK_Наименование: Зарядная станция переменного тока (AC) - EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN - MID; ADSK_Наименование краткое: Инвертор EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN - MID
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/5f9/trggp66xrecvcamv0k10y73ros0lqtve.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1659/EC22CMIDS/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN - MID; Описание: Зарядные станции ДКС подходят для частного и коммерческого использования. За вашу безопасность и защиту вашего электромобиля отвечают высококачественные компоненты европейского производства. Функция динамической балансировки нагрузки обеспечивает оптимальную зарядку электромобиля.
Type - Материалы и отделка - Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC002883; Защита от поражения электрическим током: Класс I; Имя семейства: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC; Интерфейсы связи: Wi-Fi-LAN/Ethernet (RJ-45); Класс защиты IK: IK10; Рабочая температура: -25°C ÷ +50°C; Степень защиты: IP 54
Type - Размеры - ADSK_Размер_Высота: 497 mm; ADSK_Размер_Глубина: 150 mm; ADSK_Размер_Ширина: 315 mm
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Коэффициент мощности: 1; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 22000 W; ADSK_Полная мощность: 22000 W; ADSK_Ток: 32 A
Pset_BuildingElementProxyCommon - Reference: EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN - MID
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 132
Прочее - Код типа: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN - MID; Семейство: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN - MID; Семейство и типоразмер: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN - MID; Тип: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN - MID
Размеры - Объем: 0.0234833 m3; Площадь: 0.278355 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-22000 В·А

# IfcBuildingElementProxy: EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN - Power Meter, EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC:EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN - Power Meter:625071
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Корпус_Серый, DKC_Корпус_Зеленый
Type - Данные - ADSK_Количество: 1; ADSK_Масса: 8; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EC22CMETS; ADSK_Марка: EOS Charge; ADSK_Масса_Текст: 8; ADSK_Наименование: Зарядная станция переменного тока (AC) - EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN - Power Meter; ADSK_Наименование краткое: Инвертор EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN - Power Meter
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/5f9/trggp66xrecvcamv0k10y73ros0lqtve.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1659/EC22CMETS/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN - Power Meter; Описание: Зарядные станции ДКС подходят для частного и коммерческого использования. За вашу безопасность и защиту вашего электромобиля отвечают высококачественные компоненты европейского производства. Функция динамической балансировки нагрузки обеспечивает оптимальную зарядку электромобиля.
Type - Материалы и отделка - Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC002883; Защита от поражения электрическим током: Класс I; Имя семейства: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC; Интерфейсы связи: Wi-Fi-LAN/Ethernet (RJ-45); Класс защиты IK: IK10; Рабочая температура: -25°C ÷ +50°C; Степень защиты: IP 54
Type - Размеры - ADSK_Размер_Высота: 497 mm; ADSK_Размер_Глубина: 150 mm; ADSK_Размер_Ширина: 315 mm
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Коэффициент мощности: 1; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 22000 W; ADSK_Полная мощность: 22000 W; ADSK_Ток: 32 A
Pset_BuildingElementProxyCommon - Reference: EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN - Power Meter
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 133
Прочее - Код типа: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN - Power Meter; Семейство: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN - Power Meter; Семейство и типоразмер: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN - Power Meter; Тип: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN - Power Meter
Размеры - Объем: 0.0234833 m3; Площадь: 0.278355 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-22000 В·А

# IfcBuildingElementProxy: EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN - Power Meter - MID, EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC:EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN - Power Meter - MID:625072
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Корпус_Серый, DKC_Корпус_Зеленый
Type - Данные - ADSK_Количество: 1; ADSK_Масса: 8; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EC22CPLUSS; ADSK_Марка: EOS Charge; ADSK_Масса_Текст: 8; ADSK_Наименование: Зарядная станция переменного тока (AC) - EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN - Power Meter - MID; ADSK_Наименование краткое: Инвертор EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN - Power Meter - MID
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/5f9/trggp66xrecvcamv0k10y73ros0lqtve.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1659/EC22CPLUSS/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN - Power Meter - MID; Описание: Зарядные станции ДКС подходят для частного и коммерческого использования. За вашу безопасность и защиту вашего электромобиля отвечают высококачественные компоненты европейского производства. Функция динамической балансировки нагрузки обеспечивает оптимальную зарядку электромобиля.
Type - Материалы и отделка - Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC002883; Защита от поражения электрическим током: Класс I; Имя семейства: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC; Интерфейсы связи: Wi-Fi-LAN/Ethernet (RJ-45); Класс защиты IK: IK10; Рабочая температура: -25°C ÷ +50°C; Степень защиты: IP 54
Type - Размеры - ADSK_Размер_Высота: 497 mm; ADSK_Размер_Глубина: 150 mm; ADSK_Размер_Ширина: 315 mm
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Коэффициент мощности: 1; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 22000 W; ADSK_Полная мощность: 22000 W; ADSK_Ток: 32 A
Pset_BuildingElementProxyCommon - Reference: EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN - Power Meter - MID
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 134
Прочее - Код типа: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN - Power Meter - MID; Семейство: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN - Power Meter - MID; Семейство и типоразмер: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN - Power Meter - MID; Тип: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 22kW - T2C 5m - RFID - WiFi - LAN - Power Meter - MID
Размеры - Объем: 0.0234833 m3; Площадь: 0.278355 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-22000 В·А

# IfcBuildingElementProxy: EOS Charge 22kW - T2S - RFID - WiFi - LAN, EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC:EOS Charge 22kW - T2S - RFID - WiFi - LAN:625073
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Корпус_Серый, DKC_Корпус_Зеленый
Type - Данные - ADSK_Количество: 1; ADSK_Масса: 8; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EC22SCOMS; ADSK_Марка: EOS Charge; ADSK_Масса_Текст: 8; ADSK_Наименование: Зарядная станция переменного тока (AC) - EOS Charge 22kW - T2S - RFID - WiFi - LAN; ADSK_Наименование краткое: Инвертор EOS Charge 22kW - T2S - RFID - WiFi - LAN
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/5f9/trggp66xrecvcamv0k10y73ros0lqtve.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1659/EC22SCOMS/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Charge 22kW - T2S - RFID - WiFi - LAN; Описание: Зарядные станции ДКС подходят для частного и коммерческого использования. За вашу безопасность и защиту вашего электромобиля отвечают высококачественные компоненты европейского производства. Функция динамической балансировки нагрузки обеспечивает оптимальную зарядку электромобиля.
Type - Материалы и отделка - Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC002883; Защита от поражения электрическим током: Класс I; Имя семейства: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC; Интерфейсы связи: Wi-Fi-LAN/Ethernet (RJ-45); Класс защиты IK: IK10; Рабочая температура: -25°C ÷ +50°C; Степень защиты: IP 54
Type - Размеры - ADSK_Размер_Высота: 497 mm; ADSK_Размер_Глубина: 150 mm; ADSK_Размер_Ширина: 315 mm
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Коэффициент мощности: 1; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 22000 W; ADSK_Полная мощность: 22000 W; ADSK_Ток: 32 A
Pset_BuildingElementProxyCommon - Reference: EOS Charge 22kW - T2S - RFID - WiFi - LAN
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 135
Прочее - Код типа: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 22kW - T2S - RFID - WiFi - LAN; Семейство: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 22kW - T2S - RFID - WiFi - LAN; Семейство и типоразмер: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 22kW - T2S - RFID - WiFi - LAN; Тип: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 22kW - T2S - RFID - WiFi - LAN
Размеры - Объем: 0.0234833 m3; Площадь: 0.278355 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-22000 В·А

# IfcBuildingElementProxy: EOS Charge 22kW - T2S - RFID - WiFi - LAN - MID, EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC:EOS Charge 22kW - T2S - RFID - WiFi - LAN - MID:625074
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Корпус_Серый, DKC_Корпус_Зеленый
Type - Данные - ADSK_Количество: 1; ADSK_Масса: 8; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EC22SMIDS; ADSK_Марка: EOS Charge; ADSK_Масса_Текст: 8; ADSK_Наименование: Зарядная станция переменного тока (AC) - EOS Charge 22kW - T2S - RFID - WiFi - LAN - MID; ADSK_Наименование краткое: Инвертор EOS Charge 22kW - T2S - RFID - WiFi - LAN - MID
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/5f9/trggp66xrecvcamv0k10y73ros0lqtve.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1659/EC22SMIDS/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Charge 22kW - T2S - RFID - WiFi - LAN - MID; Описание: Зарядные станции ДКС подходят для частного и коммерческого использования. За вашу безопасность и защиту вашего электромобиля отвечают высококачественные компоненты европейского производства. Функция динамической балансировки нагрузки обеспечивает оптимальную зарядку электромобиля.
Type - Материалы и отделка - Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC002883; Защита от поражения электрическим током: Класс I; Имя семейства: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC; Интерфейсы связи: Wi-Fi-LAN/Ethernet (RJ-45); Класс защиты IK: IK10; Рабочая температура: -25°C ÷ +50°C; Степень защиты: IP 54
Type - Размеры - ADSK_Размер_Высота: 497 mm; ADSK_Размер_Глубина: 150 mm; ADSK_Размер_Ширина: 315 mm
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Коэффициент мощности: 1; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 22000 W; ADSK_Полная мощность: 22000 W; ADSK_Ток: 32 A
Pset_BuildingElementProxyCommon - Reference: EOS Charge 22kW - T2S - RFID - WiFi - LAN - MID
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 136
Прочее - Код типа: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 22kW - T2S - RFID - WiFi - LAN - MID; Семейство: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 22kW - T2S - RFID - WiFi - LAN - MID; Семейство и типоразмер: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 22kW - T2S - RFID - WiFi - LAN - MID; Тип: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 22kW - T2S - RFID - WiFi - LAN - MID
Размеры - Объем: 0.0234833 m3; Площадь: 0.278355 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-22000 В·А

# IfcBuildingElementProxy: EOS Charge 22kW - T2S - RFID - WiFi - LAN - Power Meter, EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC:EOS Charge 22kW - T2S - RFID - WiFi - LAN - Power Meter:625075
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Корпус_Серый, DKC_Корпус_Зеленый
Type - Данные - ADSK_Количество: 1; ADSK_Масса: 8; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EC22SMETS; ADSK_Марка: EOS Charge; ADSK_Масса_Текст: 8; ADSK_Наименование: Зарядная станция переменного тока (AC) - EOS Charge 22kW - T2S - RFID - WiFi - LAN - Power Meter; ADSK_Наименование краткое: Инвертор EOS Charge 22kW - T2S - RFID - WiFi - LAN - Power Meter
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/5f9/trggp66xrecvcamv0k10y73ros0lqtve.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1659/EC22SMETS/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Charge 22kW - T2S - RFID - WiFi - LAN - Power Meter; Описание: Зарядные станции ДКС подходят для частного и коммерческого использования. За вашу безопасность и защиту вашего электромобиля отвечают высококачественные компоненты европейского производства. Функция динамической балансировки нагрузки обеспечивает оптимальную зарядку электромобиля.
Type - Материалы и отделка - Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC002883; Защита от поражения электрическим током: Класс I; Имя семейства: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC; Интерфейсы связи: Wi-Fi-LAN/Ethernet (RJ-45); Класс защиты IK: IK10; Рабочая температура: -25°C ÷ +50°C; Степень защиты: IP 54
Type - Размеры - ADSK_Размер_Высота: 497 mm; ADSK_Размер_Глубина: 150 mm; ADSK_Размер_Ширина: 315 mm
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Коэффициент мощности: 1; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 22000 W; ADSK_Полная мощность: 22000 W; ADSK_Ток: 32 A
Pset_BuildingElementProxyCommon - Reference: EOS Charge 22kW - T2S - RFID - WiFi - LAN - Power Meter
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 137
Прочее - Код типа: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 22kW - T2S - RFID - WiFi - LAN - Power Meter; Семейство: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 22kW - T2S - RFID - WiFi - LAN - Power Meter; Семейство и типоразмер: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 22kW - T2S - RFID - WiFi - LAN - Power Meter; Тип: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 22kW - T2S - RFID - WiFi - LAN - Power Meter
Размеры - Объем: 0.0234833 m3; Площадь: 0.278355 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-22000 В·А

# IfcBuildingElementProxy: EOS Charge 22kW - T2S - RFID - WiFi - LAN - Power Meter - MID, EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC:EOS Charge 22kW - T2S - RFID - WiFi - LAN - Power Meter - MID:625076
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Корпус_Серый, DKC_Корпус_Зеленый
Type - Данные - ADSK_Количество: 1; ADSK_Масса: 8; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EC22SPLUSS; ADSK_Марка: EOS Charge; ADSK_Масса_Текст: 8; ADSK_Наименование: Зарядная станция переменного тока (AC) - EOS Charge 22kW - T2S - RFID - WiFi - LAN - Power Meter - MID; ADSK_Наименование краткое: Инвертор EOS Charge 22kW - T2S - RFID - WiFi - LAN - Power Meter - MID
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/5f9/trggp66xrecvcamv0k10y73ros0lqtve.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1659/EC22SPLUSS/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Charge 22kW - T2S - RFID - WiFi - LAN - Power Meter - MID; Описание: Зарядные станции ДКС подходят для частного и коммерческого использования. За вашу безопасность и защиту вашего электромобиля отвечают высококачественные компоненты европейского производства. Функция динамической балансировки нагрузки обеспечивает оптимальную зарядку электромобиля.
Type - Материалы и отделка - Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC002883; Защита от поражения электрическим током: Класс I; Имя семейства: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC; Интерфейсы связи: Wi-Fi-LAN/Ethernet (RJ-45); Класс защиты IK: IK10; Рабочая температура: -25°C ÷ +50°C; Степень защиты: IP 54
Type - Размеры - ADSK_Размер_Высота: 497 mm; ADSK_Размер_Глубина: 150 mm; ADSK_Размер_Ширина: 315 mm
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Коэффициент мощности: 1; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 22000 W; ADSK_Полная мощность: 22000 W; ADSK_Ток: 32 A
Pset_BuildingElementProxyCommon - Reference: EOS Charge 22kW - T2S - RFID - WiFi - LAN - Power Meter - MID
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 138
Прочее - Код типа: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 22kW - T2S - RFID - WiFi - LAN - Power Meter - MID; Семейство: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 22kW - T2S - RFID - WiFi - LAN - Power Meter - MID; Семейство и типоразмер: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 22kW - T2S - RFID - WiFi - LAN - Power Meter - MID; Тип: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 22kW - T2S - RFID - WiFi - LAN - Power Meter - MID
Размеры - Объем: 0.0234833 m3; Площадь: 0.278355 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-22000 В·А

# IfcBuildingElementProxy: EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN, EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC:EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN:625061
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Корпус_Серый, DKC_Корпус_Зеленый
Type - Данные - ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EC7CCOMS; ADSK_Количество: 1; ADSK_Марка: EOS Charge; ADSK_Масса: 8; ADSK_Масса_Текст: 8; ADSK_Материал: DKC_Корпус_Черный; ADSK_Наименование: Зарядная станция переменного тока (AC) - EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN; ADSK_Наименование краткое: Инвертор EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/5f9/trggp66xrecvcamv0k10y73ros0lqtve.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1659/EC7CCOMS/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN; Описание: Зарядные станции ДКС подходят для частного и коммерческого использования. За вашу безопасность и защиту вашего электромобиля отвечают высококачественные компоненты европейского производства. Функция динамической балансировки нагрузки обеспечивает оптимальную зарядку электромобиля.
Type - Материалы и отделка - Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC002883; Защита от поражения электрическим током: Класс I; Имя семейства: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC; Интерфейсы связи: Wi-Fi-LAN/Ethernet (RJ-45); Класс защиты IK: IK10; Рабочая температура: -25°C ÷ +50°C; Степень защиты: IP 54
Type - Размеры - ADSK_Размер_Высота: 497 mm; ADSK_Размер_Глубина: 150 mm; ADSK_Размер_Ширина: 315 mm
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 1; ADSK_Количество фаз числовое: 1; ADSK_Коэффициент мощности: 1; ADSK_Напряжение: 230 V; ADSK_Номинальная мощность: 7400 W; ADSK_Полная мощность: 7400 W; ADSK_Ток: 32 A
Pset_BuildingElementProxyCommon - Reference: EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Марка: 123
Прочее - Код типа: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN; Семейство: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN; Семейство и типоразмер: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN; Тип: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN
Размеры - Объем: 0.0234833 m3; Площадь: 0.278355 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 230 В/1-7400 В·А

# IfcBuildingElementProxy: EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN - MID, EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC:EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN - MID:625062
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Корпус_Серый, DKC_Корпус_Зеленый
Type - Данные - ADSK_Количество: 1; ADSK_Масса: 8; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EC7CMIDS; ADSK_Марка: EOS Charge; ADSK_Масса_Текст: 8; ADSK_Наименование: Зарядная станция переменного тока (AC) - EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN - MID; ADSK_Наименование краткое: Инвертор EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN - MID
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/5f9/trggp66xrecvcamv0k10y73ros0lqtve.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1659/EC7CMIDS/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN - MID; Описание: Зарядные станции ДКС подходят для частного и коммерческого использования. За вашу безопасность и защиту вашего электромобиля отвечают высококачественные компоненты европейского производства. Функция динамической балансировки нагрузки обеспечивает оптимальную зарядку электромобиля.
Type - Материалы и отделка - Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC002883; Защита от поражения электрическим током: Класс I; Имя семейства: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC; Интерфейсы связи: Wi-Fi-LAN/Ethernet (RJ-45); Класс защиты IK: IK10; Рабочая температура: -25°C ÷ +50°C; Степень защиты: IP 54
Type - Размеры - ADSK_Размер_Высота: 497 mm; ADSK_Размер_Глубина: 150 mm; ADSK_Размер_Ширина: 315 mm
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 1; ADSK_Количество фаз числовое: 1; ADSK_Коэффициент мощности: 1; ADSK_Напряжение: 230 V; ADSK_Номинальная мощность: 7400 W; ADSK_Полная мощность: 7400 W; ADSK_Ток: 32 A
Pset_BuildingElementProxyCommon - Reference: EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN - MID
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 124
Прочее - Код типа: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN - MID; Семейство: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN - MID; Семейство и типоразмер: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN - MID; Тип: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN - MID
Размеры - Объем: 0.0234833 m3; Площадь: 0.278355 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 230 В/1-7400 В·А

# IfcBuildingElementProxy: EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN - Power Meter, EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC:EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN - Power Meter:625063
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Корпус_Серый, DKC_Корпус_Зеленый
Type - Данные - ADSK_Количество: 1; ADSK_Масса: 8; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EC7CMETS; ADSK_Марка: EOS Charge; ADSK_Масса_Текст: 8; ADSK_Наименование: Зарядная станция переменного тока (AC) - EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN - Power Meter; ADSK_Наименование краткое: Инвертор EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN - Power Meter
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/5f9/trggp66xrecvcamv0k10y73ros0lqtve.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1659/EC7CMETS/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN - Power Meter; Описание: Зарядные станции ДКС подходят для частного и коммерческого использования. За вашу безопасность и защиту вашего электромобиля отвечают высококачественные компоненты европейского производства. Функция динамической балансировки нагрузки обеспечивает оптимальную зарядку электромобиля.
Type - Материалы и отделка - Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC002883; Защита от поражения электрическим током: Класс I; Имя семейства: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC; Интерфейсы связи: Wi-Fi-LAN/Ethernet (RJ-45); Класс защиты IK: IK10; Рабочая температура: -25°C ÷ +50°C; Степень защиты: IP 54
Type - Размеры - ADSK_Размер_Высота: 497 mm; ADSK_Размер_Глубина: 150 mm; ADSK_Размер_Ширина: 315 mm
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 1; ADSK_Количество фаз числовое: 1; ADSK_Коэффициент мощности: 1; ADSK_Напряжение: 230 V; ADSK_Номинальная мощность: 7400 W; ADSK_Полная мощность: 7400 W; ADSK_Ток: 32 A
Pset_BuildingElementProxyCommon - Reference: EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN - Power Meter
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 125
Прочее - Код типа: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN - Power Meter; Семейство: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN - Power Meter; Семейство и типоразмер: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN - Power Meter; Тип: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN - Power Meter
Размеры - Объем: 0.0234833 m3; Площадь: 0.278355 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 230 В/1-7400 В·А

# IfcBuildingElementProxy: EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN - Power Meter - MID, EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC:EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN - Power Meter - MID:625064
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Корпус_Серый, DKC_Корпус_Зеленый
Type - Данные - ADSK_Количество: 1; ADSK_Масса: 8; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EC7CPLUSS; ADSK_Марка: EOS Charge; ADSK_Масса_Текст: 8; ADSK_Наименование: Зарядная станция переменного тока (AC) - EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN - Power Meter - MID; ADSK_Наименование краткое: Инвертор EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN - Power Meter - MID
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/5f9/trggp66xrecvcamv0k10y73ros0lqtve.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1659/EC7CPLUSS/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN - Power Meter - MID; Описание: Зарядные станции ДКС подходят для частного и коммерческого использования. За вашу безопасность и защиту вашего электромобиля отвечают высококачественные компоненты европейского производства. Функция динамической балансировки нагрузки обеспечивает оптимальную зарядку электромобиля.
Type - Материалы и отделка - Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC002883; Защита от поражения электрическим током: Класс I; Имя семейства: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC; Интерфейсы связи: Wi-Fi-LAN/Ethernet (RJ-45); Класс защиты IK: IK10; Рабочая температура: -25°C ÷ +50°C; Степень защиты: IP 54
Type - Размеры - ADSK_Размер_Высота: 497 mm; ADSK_Размер_Глубина: 150 mm; ADSK_Размер_Ширина: 315 mm
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 1; ADSK_Количество фаз числовое: 1; ADSK_Коэффициент мощности: 1; ADSK_Напряжение: 230 V; ADSK_Номинальная мощность: 7400 W; ADSK_Полная мощность: 7400 W; ADSK_Ток: 32 A
Pset_BuildingElementProxyCommon - Reference: EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN - Power Meter - MID
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 126
Прочее - Код типа: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN - Power Meter - MID; Семейство: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN - Power Meter - MID; Семейство и типоразмер: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN - Power Meter - MID; Тип: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 7,4kW - T2C 5m - RFID - WiFi - LAN - Power Meter - MID
Размеры - Объем: 0.0234833 m3; Площадь: 0.278355 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 230 В/1-7400 В·А

# IfcBuildingElementProxy: EOS Charge 7,4kW - T2S - RFID - WiFi - LAN, EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC:EOS Charge 7,4kW - T2S - RFID - WiFi - LAN:625065
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Корпус_Серый, DKC_Корпус_Зеленый
Type - Данные - ADSK_Количество: 1; ADSK_Масса: 8; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EC7SCOMS; ADSK_Марка: EOS Charge; ADSK_Масса_Текст: 8; ADSK_Наименование: Зарядная станция переменного тока (AC) - EOS Charge 7,4kW - T2S - RFID - WiFi - LAN; ADSK_Наименование краткое: Инвертор EOS Charge 7,4kW - T2S - RFID - WiFi - LAN
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/5f9/trggp66xrecvcamv0k10y73ros0lqtve.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1659/EC7SCOMS/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Charge 7,4kW - T2S - RFID - WiFi - LAN; Описание: Зарядные станции ДКС подходят для частного и коммерческого использования. За вашу безопасность и защиту вашего электромобиля отвечают высококачественные компоненты европейского производства. Функция динамической балансировки нагрузки обеспечивает оптимальную зарядку электромобиля.
Type - Материалы и отделка - Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC002883; Защита от поражения электрическим током: Класс I; Имя семейства: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC; Интерфейсы связи: Wi-Fi-LAN/Ethernet (RJ-45); Класс защиты IK: IK10; Рабочая температура: -25°C ÷ +50°C; Степень защиты: IP 54
Type - Размеры - ADSK_Размер_Высота: 497 mm; ADSK_Размер_Глубина: 150 mm; ADSK_Размер_Ширина: 315 mm
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 1; ADSK_Количество фаз числовое: 1; ADSK_Коэффициент мощности: 1; ADSK_Напряжение: 230 V; ADSK_Номинальная мощность: 7400 W; ADSK_Полная мощность: 7400 W; ADSK_Ток: 32 A
Pset_BuildingElementProxyCommon - Reference: EOS Charge 7,4kW - T2S - RFID - WiFi - LAN
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 127
Прочее - Код типа: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 7,4kW - T2S - RFID - WiFi - LAN; Семейство: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 7,4kW - T2S - RFID - WiFi - LAN; Семейство и типоразмер: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 7,4kW - T2S - RFID - WiFi - LAN; Тип: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 7,4kW - T2S - RFID - WiFi - LAN
Размеры - Объем: 0.0234833 m3; Площадь: 0.278355 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 230 В/1-7400 В·А

# IfcBuildingElementProxy: EOS Charge 7,4kW - T2S - RFID - WiFi - LAN - MID, EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC:EOS Charge 7,4kW - T2S - RFID - WiFi - LAN - MID:625066
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Корпус_Серый, DKC_Корпус_Зеленый
Type - Данные - ADSK_Количество: 1; ADSK_Масса: 8; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EC7SMIDS; ADSK_Марка: EOS Charge; ADSK_Масса_Текст: 8; ADSK_Наименование: Зарядная станция переменного тока (AC) - EOS Charge 7,4kW - T2S - RFID - WiFi - LAN - MID; ADSK_Наименование краткое: Инвертор EOS Charge 7,4kW - T2S - RFID - WiFi - LAN - MID
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/5f9/trggp66xrecvcamv0k10y73ros0lqtve.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1659/EC7SMIDS/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Charge 7,4kW - T2S - RFID - WiFi - LAN - MID; Описание: Зарядные станции ДКС подходят для частного и коммерческого использования. За вашу безопасность и защиту вашего электромобиля отвечают высококачественные компоненты европейского производства. Функция динамической балансировки нагрузки обеспечивает оптимальную зарядку электромобиля.
Type - Материалы и отделка - Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC002883; Защита от поражения электрическим током: Класс I; Имя семейства: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC; Интерфейсы связи: Wi-Fi-LAN/Ethernet (RJ-45); Класс защиты IK: IK10; Рабочая температура: -25°C ÷ +50°C; Степень защиты: IP 54
Type - Размеры - ADSK_Размер_Высота: 497 mm; ADSK_Размер_Глубина: 150 mm; ADSK_Размер_Ширина: 315 mm
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 1; ADSK_Количество фаз числовое: 1; ADSK_Коэффициент мощности: 1; ADSK_Напряжение: 230 V; ADSK_Номинальная мощность: 7400 W; ADSK_Полная мощность: 7400 W; ADSK_Ток: 32 A
Pset_BuildingElementProxyCommon - Reference: EOS Charge 7,4kW - T2S - RFID - WiFi - LAN - MID
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 128
Прочее - Код типа: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 7,4kW - T2S - RFID - WiFi - LAN - MID; Семейство: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 7,4kW - T2S - RFID - WiFi - LAN - MID; Семейство и типоразмер: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 7,4kW - T2S - RFID - WiFi - LAN - MID; Тип: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 7,4kW - T2S - RFID - WiFi - LAN - MID
Размеры - Объем: 0.0234833 m3; Площадь: 0.278355 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 230 В/1-7400 В·А

# IfcBuildingElementProxy: EOS Charge 7,4kW - T2S - RFID - WiFi - LAN - Power Meter, EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC:EOS Charge 7,4kW - T2S - RFID - WiFi - LAN - Power Meter:625067
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Корпус_Серый, DKC_Корпус_Зеленый
Type - Данные - ADSK_Количество: 1; ADSK_Масса: 8; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EC7SMETS; ADSK_Марка: EOS Charge; ADSK_Масса_Текст: 8; ADSK_Наименование: Зарядная станция переменного тока (AC) - EOS Charge 7,4kW - T2S - RFID - WiFi - LAN - Power Meter; ADSK_Наименование краткое: Инвертор EOS Charge 7,4kW - T2S - RFID - WiFi - LAN - Power Meter
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/5f9/trggp66xrecvcamv0k10y73ros0lqtve.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1659/EC7SMETS/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Charge 7,4kW - T2S - RFID - WiFi - LAN - Power Meter; Описание: Зарядные станции ДКС подходят для частного и коммерческого использования. За вашу безопасность и защиту вашего электромобиля отвечают высококачественные компоненты европейского производства. Функция динамической балансировки нагрузки обеспечивает оптимальную зарядку электромобиля.
Type - Материалы и отделка - Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC002883; Защита от поражения электрическим током: Класс I; Имя семейства: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC; Интерфейсы связи: Wi-Fi-LAN/Ethernet (RJ-45); Класс защиты IK: IK10; Рабочая температура: -25°C ÷ +50°C; Степень защиты: IP 54
Type - Размеры - ADSK_Размер_Высота: 497 mm; ADSK_Размер_Глубина: 150 mm; ADSK_Размер_Ширина: 315 mm
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 1; ADSK_Количество фаз числовое: 1; ADSK_Коэффициент мощности: 1; ADSK_Напряжение: 230 V; ADSK_Номинальная мощность: 7400 W; ADSK_Полная мощность: 7400 W; ADSK_Ток: 32 A
Pset_BuildingElementProxyCommon - Reference: EOS Charge 7,4kW - T2S - RFID - WiFi - LAN - Power Meter
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 129
Прочее - Код типа: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 7,4kW - T2S - RFID - WiFi - LAN - Power Meter; Семейство: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 7,4kW - T2S - RFID - WiFi - LAN - Power Meter; Семейство и типоразмер: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 7,4kW - T2S - RFID - WiFi - LAN - Power Meter; Тип: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 7,4kW - T2S - RFID - WiFi - LAN - Power Meter
Размеры - Объем: 0.0234833 m3; Площадь: 0.278355 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 230 В/1-7400 В·А

# IfcBuildingElementProxy: EOS Charge 7,4kW - T2S - RFID - WiFi - LAN - Power Meter - MID, EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC:EOS Charge 7,4kW - T2S - RFID - WiFi - LAN - Power Meter - MID:625068
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Корпус_Серый, DKC_Корпус_Зеленый
Type - Данные - ADSK_Количество: 1; ADSK_Масса: 8; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EC7SPLUSS; ADSK_Марка: EOS Charge; ADSK_Масса_Текст: 8; ADSK_Наименование: Зарядная станция переменного тока (AC) - EOS Charge 7,4kW - T2S - RFID - WiFi - LAN - Power Meter - MID; ADSK_Наименование краткое: Инвертор EOS Charge 7,4kW - T2S - RFID - WiFi - LAN - Power Meter - MID
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/5f9/trggp66xrecvcamv0k10y73ros0lqtve.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1659/EC7SPLUSS/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Charge 7,4kW - T2S - RFID - WiFi - LAN - Power Meter - MID; Описание: Зарядные станции ДКС подходят для частного и коммерческого использования. За вашу безопасность и защиту вашего электромобиля отвечают высококачественные компоненты европейского производства. Функция динамической балансировки нагрузки обеспечивает оптимальную зарядку электромобиля.
Type - Материалы и отделка - Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC002883; Защита от поражения электрическим током: Класс I; Имя семейства: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC; Интерфейсы связи: Wi-Fi-LAN/Ethernet (RJ-45); Класс защиты IK: IK10; Рабочая температура: -25°C ÷ +50°C; Степень защиты: IP 54
Type - Размеры - ADSK_Размер_Высота: 497 mm; ADSK_Размер_Глубина: 150 mm; ADSK_Размер_Ширина: 315 mm
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 1; ADSK_Количество фаз числовое: 1; ADSK_Коэффициент мощности: 1; ADSK_Напряжение: 230 V; ADSK_Номинальная мощность: 7400 W; ADSK_Полная мощность: 7400 W; ADSK_Ток: 32 A
Pset_BuildingElementProxyCommon - Reference: EOS Charge 7,4kW - T2S - RFID - WiFi - LAN - Power Meter - MID
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 130
Прочее - Код типа: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 7,4kW - T2S - RFID - WiFi - LAN - Power Meter - MID; Семейство: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 7,4kW - T2S - RFID - WiFi - LAN - Power Meter - MID; Семейство и типоразмер: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 7,4kW - T2S - RFID - WiFi - LAN - Power Meter - MID; Тип: EOS_ЗаряднаяСтанцияПеременногоТока_EOS-Charge_7-22кВт_DKC: EOS Charge 7,4kW - T2S - RFID - WiFi - LAN - Power Meter - MID
Размеры - Объем: 0.0234833 m3; Площадь: 0.278355 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 230 В/1-7400 В·А

# IfcBuildingElementProxy: Текст модели:75 мм Arial (16)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 75 мм Arial
Графика - Горизонтальное выравнивание: По центру
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели
Материалы и отделка - Материал: DKC_СерыйЛого
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 75 мм Arial; Семейство: Текст модели: 75 мм Arial; Семейство и типоразмер: Текст модели: 75 мм Arial; Тип: Текст модели: 75 мм Arial
Размеры - Глубина:: 5 mm
Стадии - Стадия возведения: Стадия 1
Текст(Type) - Жирный: no; Курсив: no; Размер текста: 75 mm; Шрифт текста: Arial
Прочее(Type) - Категория: Обобщенные модели; Имя семейства: Текст модели
Идентификация(Type) - Имя типа: 75 мм Arial
Name (Текст модели:...) | Текст | Вариант конструкции
4 x 75 мм Arial | 7,4 кВт | Оформление каталога (основной)
4 x 75 мм Arial | 7,4 кВт | Оформление каталога : Оформление каталога
4 x 75 мм Arial | 22 кВт | Оформление каталога : Оформление каталога
4 x 75 мм Arial | 22 кВт | Оформление каталога (основной)
