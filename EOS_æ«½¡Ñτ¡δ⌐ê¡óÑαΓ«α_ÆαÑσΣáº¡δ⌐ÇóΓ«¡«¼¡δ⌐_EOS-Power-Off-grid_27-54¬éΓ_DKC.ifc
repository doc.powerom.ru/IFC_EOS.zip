Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-04-23T18:57:51
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181217_1515(x64) - Exporter 19.2.0.65 - Альтернативный интерфейс 19.2.0.65
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Apr 23 18:57:51 2024 * Host: WIN-0P1AU7TJQME * Database: C:\Users\user\AppData\Local\Temp\{F767DD99-2D6D-4537-A14A-9AB254AD9815}\ifc * Database version: 5507 * Database creation date: Tue Apr 23 18:57:50 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Apr 23 18:57:50 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Apr 23 18:57:50 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2022
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2022
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее(Type) - Категория: Уровни; Имя семейства: Уровень
Идентификация(Type) - Имя типа: Отметка уровня с именем
Зависимости(Type) - Базовая отметка: Базовая точка проекта
Графика(Type) - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: Сплошная; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Зависимости - Фасад: 0 mm
Идентификация - Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Прочее - Категория: Уровни; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: EOS Power Off-grid 27 кВт/2MPPT, EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC:EOS Power Off-grid 27 кВт/2MPPT:625034
In: Этаж 01
Type - Material: DKC_Корпус_Светло-серый, DKC_Корпус_Красный, DKC_Корпус_Черный
Type - Данные - ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPA050D027A; ADSK_Количество: 1; ADSK_Марка: EOS Power Off-grid; ADSK_Масса: 360; ADSK_Масса_Текст: 360; ADSK_Материал: DKC_Корпус_Черный; ADSK_Наименование: Трехфазный солнечный инвертор EOS Power Off-grid 27 кВт/2MPPT; ADSK_Наименование краткое: Инвертор EOS Power Off-grid 27 кВт/2MPPT
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/72b/resia6gep1pqefg0cc9k1rsdxfa1alqe.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1759/EPA050D027A/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power Off-grid 27 кВт/2MPPT; Описание: Автономные солнечные инверторы используются для создания систем независимого электроснабжения потребителей там, где это необходимо: в доме, коттедже, предприятии и т.д. Аккумулируя и пропуская через инвертор солнечную энергию, вырабатываемую фотоэлектрическими панелями, а также энергию от дополнительных источников питания - сети и дизель-генератора - можно предоставлять эту энергию по мере необходимости потребителям, обеспечивать стабильное штатное и аварийное их питание.
Type - Материалы и отделка - Материал_Зона обслуживания: DKC_Зона обслуживания; Материал_Логотип: DKC_Корпус_Красный; Материал_Панель управления: DKC_Корпус_Черный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC; Интерфейсы связи: RS232/RS485/USB/реле (базовые); SNMP/Wi-Fi/GPRS (опция); Рабочая температура: 0°С ~ 40°С; Степень защиты: IP 20
Type - Размеры - ADSK_Размер_Высота: 1750 mm; ADSK_Размер_Глубина: 700 mm; ADSK_Размер_Ширина: 600 mm
Type - Электросети - Номинальное напряжение АКБ: 360 V; Полная мощность АКБ: 0 W
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Коэффициент мощности: 0.9; ADSK_КПД: 92; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 27000 W; ADSK_Полная мощность: 30000 W; ADSK_Ток: 120 A
Pset_BuildingElementProxyCommon - Reference: EOS Power Off-grid 27 кВт/2MPPT
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - ADSK_Зона обслуживания: yes
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Марка: 52
Прочее - Код типа: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC: EOS Power Off-grid 27 кВт/2MPPT; Семейство: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC: EOS Power Off-grid 27 кВт/2MPPT; Семейство и типоразмер: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC: EOS Power Off-grid 27 кВт/2MPPT; Тип: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC: EOS Power Off-grid 27 кВт/2MPPT
Размеры - Объем: 2.8392 m3; Площадь: 9.5044 m2
Свойства модели - Размер_Глубина ЗО: 1000 mm
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-30000 В·А-Подключение АКБ 360 В/3-0 В·А

# IfcBuildingElementProxy: EOS Power Off-grid 27 кВт/3MPPT, EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC:EOS Power Off-grid 27 кВт/3MPPT:625035
In: Этаж 01
Type - Material: DKC_Корпус_Светло-серый, DKC_Корпус_Красный, DKC_Корпус_Черный
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPA075D027A; ADSK_Марка: EOS Power Off-grid; ADSK_Масса: 366; ADSK_Масса_Текст: 366; ADSK_Наименование: Трехфазный солнечный инвертор EOS Power Off-grid 27 кВт/3MPPT; ADSK_Наименование краткое: Инвертор EOS Power Off-grid 27 кВт/3MPPT
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/72b/resia6gep1pqefg0cc9k1rsdxfa1alqe.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1759/EPA075D027A/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power Off-grid 27 кВт/3MPPT; Описание: Автономные солнечные инверторы используются для создания систем независимого электроснабжения потребителей там, где это необходимо: в доме, коттедже, предприятии и т.д. Аккумулируя и пропуская через инвертор солнечную энергию, вырабатываемую фотоэлектрическими панелями, а также энергию от дополнительных источников питания - сети и дизель-генератора - можно предоставлять эту энергию по мере необходимости потребителям, обеспечивать стабильное штатное и аварийное их питание.
Type - Материалы и отделка - Материал_Зона обслуживания: DKC_Зона обслуживания; Материал_Логотип: DKC_Корпус_Красный; Материал_Панель управления: DKC_Корпус_Черный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC; Интерфейсы связи: RS232/RS485/USB/реле (базовые); SNMP/Wi-Fi/GPRS (опция); Рабочая температура: 0°С ~ 40°С; Степень защиты: IP 20
Type - Размеры - ADSK_Размер_Высота: 1750 mm; ADSK_Размер_Глубина: 700 mm; ADSK_Размер_Ширина: 600 mm
Type - Электросети - Номинальное напряжение АКБ: 360 V; Полная мощность АКБ: 0 W
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Коэффициент мощности: 0.9; ADSK_КПД: 92; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 27000 W; ADSK_Полная мощность: 30000 W; ADSK_Ток: 180 A
Pset_BuildingElementProxyCommon - Reference: EOS Power Off-grid 27 кВт/3MPPT
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - ADSK_Зона обслуживания: yes
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 53
Прочее - Код типа: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC: EOS Power Off-grid 27 кВт/3MPPT; Семейство: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC: EOS Power Off-grid 27 кВт/3MPPT; Семейство и типоразмер: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC: EOS Power Off-grid 27 кВт/3MPPT; Тип: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC: EOS Power Off-grid 27 кВт/3MPPT
Размеры - Объем: 2.8392 m3; Площадь: 9.5044 m2
Свойства модели - Размер_Глубина ЗО: 1000 mm
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-30000 В·А-Подключение АКБ 360 В/3-0 В·А

# IfcBuildingElementProxy: EOS Power Off-grid 27 кВт/4MPPT, EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC:EOS Power Off-grid 27 кВт/4MPPT:625036
In: Этаж 01
Type - Material: DKC_Корпус_Светло-серый, DKC_Корпус_Красный, DKC_Корпус_Черный
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPA100D027A; ADSK_Марка: EOS Power Off-grid; ADSK_Масса: 372; ADSK_Масса_Текст: 372; ADSK_Наименование: Трехфазный солнечный инвертор EOS Power Off-grid 27 кВт/4MPPT; ADSK_Наименование краткое: Инвертор EOS Power Off-grid 27 кВт/4MPPT
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/72b/resia6gep1pqefg0cc9k1rsdxfa1alqe.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1759/EPA100D027A/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power Off-grid 27 кВт/4MPPT; Описание: Автономные солнечные инверторы используются для создания систем независимого электроснабжения потребителей там, где это необходимо: в доме, коттедже, предприятии и т.д. Аккумулируя и пропуская через инвертор солнечную энергию, вырабатываемую фотоэлектрическими панелями, а также энергию от дополнительных источников питания - сети и дизель-генератора - можно предоставлять эту энергию по мере необходимости потребителям, обеспечивать стабильное штатное и аварийное их питание.
Type - Материалы и отделка - Материал_Зона обслуживания: DKC_Зона обслуживания; Материал_Логотип: DKC_Корпус_Красный; Материал_Панель управления: DKC_Корпус_Черный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC; Интерфейсы связи: RS232/RS485/USB/реле (базовые); SNMP/Wi-Fi/GPRS (опция); Рабочая температура: 0°С ~ 40°С; Степень защиты: IP 20
Type - Размеры - ADSK_Размер_Высота: 1750 mm; ADSK_Размер_Глубина: 700 mm; ADSK_Размер_Ширина: 600 mm
Type - Электросети - Номинальное напряжение АКБ: 360 V; Полная мощность АКБ: 0 W
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Коэффициент мощности: 0.9; ADSK_КПД: 92; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 27000 W; ADSK_Полная мощность: 30000 W; ADSK_Ток: 240 A
Pset_BuildingElementProxyCommon - Reference: EOS Power Off-grid 27 кВт/4MPPT
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - ADSK_Зона обслуживания: yes
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 54
Прочее - Код типа: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC: EOS Power Off-grid 27 кВт/4MPPT; Семейство: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC: EOS Power Off-grid 27 кВт/4MPPT; Семейство и типоразмер: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC: EOS Power Off-grid 27 кВт/4MPPT; Тип: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC: EOS Power Off-grid 27 кВт/4MPPT
Размеры - Объем: 2.8392 m3; Площадь: 9.5044 m2
Свойства модели - Размер_Глубина ЗО: 1000 mm
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-30000 В·А-Подключение АКБ 360 В/3-0 В·А

# IfcBuildingElementProxy: EOS Power Off-grid 36 кВт/2MPPT, EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC:EOS Power Off-grid 36 кВт/2MPPT:625037
In: Этаж 01
Type - Material: DKC_Корпус_Светло-серый, DKC_Корпус_Красный, DKC_Корпус_Черный
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPA050D036A; ADSK_Марка: EOS Power Off-grid; ADSK_Масса: 410; ADSK_Масса_Текст: 410; ADSK_Наименование: Трехфазный солнечный инвертор EOS Power Off-grid 36 кВт/2MPPT; ADSK_Наименование краткое: Инвертор EOS Power Off-grid 36 кВт/2MPPT
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/72b/resia6gep1pqefg0cc9k1rsdxfa1alqe.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1759/EPA050D036A/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power Off-grid 36 кВт/2MPPT; Описание: Автономные солнечные инверторы используются для создания систем независимого электроснабжения потребителей там, где это необходимо: в доме, коттедже, предприятии и т.д. Аккумулируя и пропуская через инвертор солнечную энергию, вырабатываемую фотоэлектрическими панелями, а также энергию от дополнительных источников питания - сети и дизель-генератора - можно предоставлять эту энергию по мере необходимости потребителям, обеспечивать стабильное штатное и аварийное их питание.
Type - Материалы и отделка - Материал_Зона обслуживания: DKC_Зона обслуживания; Материал_Логотип: DKC_Корпус_Красный; Материал_Панель управления: DKC_Корпус_Черный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC; Интерфейсы связи: RS232/RS485/USB/реле (базовые); SNMP/Wi-Fi/GPRS (опция); Рабочая температура: 0°С ~ 40°С; Степень защиты: IP 20
Type - Размеры - ADSK_Размер_Высота: 1750 mm; ADSK_Размер_Глубина: 700 mm; ADSK_Размер_Ширина: 600 mm
Type - Электросети - Номинальное напряжение АКБ: 360 V; Полная мощность АКБ: 0 W
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Коэффициент мощности: 0.9; ADSK_КПД: 92; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 36000 W; ADSK_Полная мощность: 40000 W; ADSK_Ток: 120 A
Pset_BuildingElementProxyCommon - Reference: EOS Power Off-grid 36 кВт/2MPPT
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - ADSK_Зона обслуживания: yes
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 55
Прочее - Код типа: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC: EOS Power Off-grid 36 кВт/2MPPT; Семейство: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC: EOS Power Off-grid 36 кВт/2MPPT; Семейство и типоразмер: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC: EOS Power Off-grid 36 кВт/2MPPT; Тип: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC: EOS Power Off-grid 36 кВт/2MPPT
Размеры - Объем: 2.8392 m3; Площадь: 9.5044 m2
Свойства модели - Размер_Глубина ЗО: 1000 mm
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-40000 В·А-Подключение АКБ 360 В/3-0 В·А

# IfcBuildingElementProxy: EOS Power Off-grid 36 кВт/3MPPT, EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC:EOS Power Off-grid 36 кВт/3MPPT:625038
In: Этаж 01
Type - Material: DKC_Корпус_Светло-серый, DKC_Корпус_Красный, DKC_Корпус_Черный
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPA075D036A; ADSK_Марка: EOS Power Off-grid; ADSK_Масса: 416; ADSK_Масса_Текст: 416; ADSK_Наименование: Трехфазный солнечный инвертор EOS Power Off-grid 36 кВт/3MPPT; ADSK_Наименование краткое: Инвертор EOS Power Off-grid 36 кВт/3MPPT
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/72b/resia6gep1pqefg0cc9k1rsdxfa1alqe.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1759/EPA075D036A/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power Off-grid 36 кВт/3MPPT; Описание: Автономные солнечные инверторы используются для создания систем независимого электроснабжения потребителей там, где это необходимо: в доме, коттедже, предприятии и т.д. Аккумулируя и пропуская через инвертор солнечную энергию, вырабатываемую фотоэлектрическими панелями, а также энергию от дополнительных источников питания - сети и дизель-генератора - можно предоставлять эту энергию по мере необходимости потребителям, обеспечивать стабильное штатное и аварийное их питание.
Type - Материалы и отделка - Материал_Зона обслуживания: DKC_Зона обслуживания; Материал_Логотип: DKC_Корпус_Красный; Материал_Панель управления: DKC_Корпус_Черный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC; Интерфейсы связи: RS232/RS485/USB/реле (базовые); SNMP/Wi-Fi/GPRS (опция); Рабочая температура: 0°С ~ 40°С; Степень защиты: IP 20
Type - Размеры - ADSK_Размер_Высота: 1750 mm; ADSK_Размер_Глубина: 700 mm; ADSK_Размер_Ширина: 600 mm
Type - Электросети - Номинальное напряжение АКБ: 360 V; Полная мощность АКБ: 0 W
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Коэффициент мощности: 0.9; ADSK_КПД: 92; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 36000 W; ADSK_Полная мощность: 40000 W; ADSK_Ток: 180 A
Pset_BuildingElementProxyCommon - Reference: EOS Power Off-grid 36 кВт/3MPPT
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - ADSK_Зона обслуживания: yes
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 56
Прочее - Код типа: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC: EOS Power Off-grid 36 кВт/3MPPT; Семейство: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC: EOS Power Off-grid 36 кВт/3MPPT; Семейство и типоразмер: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC: EOS Power Off-grid 36 кВт/3MPPT; Тип: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC: EOS Power Off-grid 36 кВт/3MPPT
Размеры - Объем: 2.8392 m3; Площадь: 9.5044 m2
Свойства модели - Размер_Глубина ЗО: 1000 mm
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-40000 В·А-Подключение АКБ 360 В/3-0 В·А

# IfcBuildingElementProxy: EOS Power Off-grid 36 кВт/4MPPT, EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC:EOS Power Off-grid 36 кВт/4MPPT:625039
In: Этаж 01
Type - Material: DKC_Корпус_Светло-серый, DKC_Корпус_Красный, DKC_Корпус_Черный
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPA100D036A; ADSK_Марка: EOS Power Off-grid; ADSK_Масса: 422; ADSK_Масса_Текст: 422; ADSK_Наименование: Трехфазный солнечный инвертор EOS Power Off-grid 36 кВт/4MPPT; ADSK_Наименование краткое: Инвертор EOS Power Off-grid 36 кВт/4MPPT
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/72b/resia6gep1pqefg0cc9k1rsdxfa1alqe.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1759/EPA100D036A/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power Off-grid 36 кВт/4MPPT; Описание: Автономные солнечные инверторы используются для создания систем независимого электроснабжения потребителей там, где это необходимо: в доме, коттедже, предприятии и т.д. Аккумулируя и пропуская через инвертор солнечную энергию, вырабатываемую фотоэлектрическими панелями, а также энергию от дополнительных источников питания - сети и дизель-генератора - можно предоставлять эту энергию по мере необходимости потребителям, обеспечивать стабильное штатное и аварийное их питание.
Type - Материалы и отделка - Материал_Зона обслуживания: DKC_Зона обслуживания; Материал_Логотип: DKC_Корпус_Красный; Материал_Панель управления: DKC_Корпус_Черный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC; Интерфейсы связи: RS232/RS485/USB/реле (базовые); SNMP/Wi-Fi/GPRS (опция); Рабочая температура: 0°С ~ 40°С; Степень защиты: IP 20
Type - Размеры - ADSK_Размер_Высота: 1750 mm; ADSK_Размер_Глубина: 700 mm; ADSK_Размер_Ширина: 600 mm
Type - Электросети - Номинальное напряжение АКБ: 360 V; Полная мощность АКБ: 0 W
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Коэффициент мощности: 0.9; ADSK_КПД: 92; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 36000 W; ADSK_Полная мощность: 40000 W; ADSK_Ток: 240 A
Pset_BuildingElementProxyCommon - Reference: EOS Power Off-grid 36 кВт/4MPPT
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - ADSK_Зона обслуживания: yes
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 57
Прочее - Код типа: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC: EOS Power Off-grid 36 кВт/4MPPT; Семейство: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC: EOS Power Off-grid 36 кВт/4MPPT; Семейство и типоразмер: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC: EOS Power Off-grid 36 кВт/4MPPT; Тип: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC: EOS Power Off-grid 36 кВт/4MPPT
Размеры - Объем: 2.8392 m3; Площадь: 9.5044 m2
Свойства модели - Размер_Глубина ЗО: 1000 mm
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-40000 В·А-Подключение АКБ 360 В/3-0 В·А

# IfcBuildingElementProxy: EOS Power Off-grid 54 кВт/3MPPT, EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC:EOS Power Off-grid 54 кВт/3MPPT:625040
In: Этаж 01
Type - Material: DKC_Корпус_Светло-серый, DKC_Корпус_Красный, DKC_Корпус_Черный
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPA075D054A; ADSK_Марка: EOS Power Off-grid; ADSK_Масса: 495; ADSK_Масса_Текст: 495; ADSK_Наименование: Трехфазный солнечный инвертор EOS Power Off-grid 54 кВт/3MPPT; ADSK_Наименование краткое: Инвертор EOS Power Off-grid 54 кВт/3MPPT
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/72b/resia6gep1pqefg0cc9k1rsdxfa1alqe.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1759/EPA075D054A/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power Off-grid 54 кВт/3MPPT; Описание: Автономные солнечные инверторы используются для создания систем независимого электроснабжения потребителей там, где это необходимо: в доме, коттедже, предприятии и т.д. Аккумулируя и пропуская через инвертор солнечную энергию, вырабатываемую фотоэлектрическими панелями, а также энергию от дополнительных источников питания - сети и дизель-генератора - можно предоставлять эту энергию по мере необходимости потребителям, обеспечивать стабильное штатное и аварийное их питание.
Type - Материалы и отделка - Материал_Зона обслуживания: DKC_Зона обслуживания; Материал_Логотип: DKC_Корпус_Красный; Материал_Панель управления: DKC_Корпус_Черный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC; Интерфейсы связи: RS232/RS485/USB/реле (базовые); SNMP/Wi-Fi/GPRS (опция); Рабочая температура: 0°С ~ 40°С; Степень защиты: IP 20
Type - Размеры - ADSK_Размер_Высота: 1750 mm; ADSK_Размер_Глубина: 700 mm; ADSK_Размер_Ширина: 600 mm
Type - Электросети - Номинальное напряжение АКБ: 360 V; Полная мощность АКБ: 0 W
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Коэффициент мощности: 0.9; ADSK_КПД: 92; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 54000 W; ADSK_Полная мощность: 60000 W; ADSK_Ток: 180 A
Pset_BuildingElementProxyCommon - Reference: EOS Power Off-grid 54 кВт/3MPPT
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - ADSK_Зона обслуживания: yes
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 58
Прочее - Код типа: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC: EOS Power Off-grid 54 кВт/3MPPT; Семейство: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC: EOS Power Off-grid 54 кВт/3MPPT; Семейство и типоразмер: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC: EOS Power Off-grid 54 кВт/3MPPT; Тип: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC: EOS Power Off-grid 54 кВт/3MPPT
Размеры - Объем: 2.8392 m3; Площадь: 9.5044 m2
Свойства модели - Размер_Глубина ЗО: 1000 mm
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-60000 В·А-Подключение АКБ 360 В/3-0 В·А

# IfcBuildingElementProxy: EOS Power Off-grid 54 кВт/4MPPT, EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC:EOS Power Off-grid 54 кВт/4MPPT:625041
In: Этаж 01
Type - Material: DKC_Корпус_Светло-серый, DKC_Корпус_Красный, DKC_Корпус_Черный
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPA100D054A; ADSK_Марка: EOS Power Off-grid; ADSK_Масса: 501; ADSK_Масса_Текст: 501; ADSK_Наименование: Трехфазный солнечный инвертор EOS Power Off-grid 54 кВт/4MPPT; ADSK_Наименование краткое: Инвертор EOS Power Off-grid 54 кВт/4MPPT
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/72b/resia6gep1pqefg0cc9k1rsdxfa1alqe.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1759/EPA100D054A/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power Off-grid 54 кВт/4MPPT; Описание: Автономные солнечные инверторы используются для создания систем независимого электроснабжения потребителей там, где это необходимо: в доме, коттедже, предприятии и т.д. Аккумулируя и пропуская через инвертор солнечную энергию, вырабатываемую фотоэлектрическими панелями, а также энергию от дополнительных источников питания - сети и дизель-генератора - можно предоставлять эту энергию по мере необходимости потребителям, обеспечивать стабильное штатное и аварийное их питание.
Type - Материалы и отделка - Материал_Зона обслуживания: DKC_Зона обслуживания; Материал_Логотип: DKC_Корпус_Красный; Материал_Панель управления: DKC_Корпус_Черный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC; Интерфейсы связи: RS232/RS485/USB/реле (базовые); SNMP/Wi-Fi/GPRS (опция); Рабочая температура: 0°С ~ 40°С; Степень защиты: IP 20
Type - Размеры - ADSK_Размер_Высота: 1750 mm; ADSK_Размер_Глубина: 700 mm; ADSK_Размер_Ширина: 600 mm
Type - Электросети - Номинальное напряжение АКБ: 360 V; Полная мощность АКБ: 0 W
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Коэффициент мощности: 0.9; ADSK_КПД: 92; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 54000 W; ADSK_Полная мощность: 60000 W; ADSK_Ток: 240 A
Pset_BuildingElementProxyCommon - Reference: EOS Power Off-grid 54 кВт/4MPPT
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - ADSK_Зона обслуживания: yes
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 59
Прочее - Код типа: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC: EOS Power Off-grid 54 кВт/4MPPT; Семейство: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC: EOS Power Off-grid 54 кВт/4MPPT; Семейство и типоразмер: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC: EOS Power Off-grid 54 кВт/4MPPT; Тип: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_27-54кВт_DKC: EOS Power Off-grid 54 кВт/4MPPT
Размеры - Объем: 2.8392 m3; Площадь: 9.5044 m2
Свойства модели - Размер_Глубина ЗО: 1000 mm
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-60000 В·А-Подключение АКБ 360 В/3-0 В·А

# IfcBuildingElementProxy: Текст модели:75 мм Arial (8)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 75 мм Arial
Графика - Горизонтальное выравнивание: По центру
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели
Материалы и отделка - Материал: DKC_СерыйЛого
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 75 мм Arial; Семейство: Текст модели: 75 мм Arial; Семейство и типоразмер: Текст модели: 75 мм Arial; Тип: Текст модели: 75 мм Arial
Размеры - Глубина:: 5 mm
Стадии - Стадия возведения: Стадия 1
Текст(Type) - Жирный: no; Курсив: no; Размер текста: 75 mm; Шрифт текста: Arial
Прочее(Type) - Категория: Обобщенные модели; Имя семейства: Текст модели
Идентификация(Type) - Имя типа: 75 мм Arial
Name (Текст модели:...) | Текст | Вариант конструкции
75 мм Arial | 27 кВт/ 2MPPT | Оформление каталога : Оформление каталога
75 мм Arial | 27 кВт/ 3MPPT | Оформление каталога (основной)
75 мм Arial | 27 кВт/ 4MPPT | Оформление каталога : Оформление каталога
75 мм Arial | 36 кВт/ 2MPPT | Оформление каталога : Оформление каталога
75 мм Arial | 36 кВт/ 3MPPT | Оформление каталога : Оформление каталога
75 мм Arial | 36 кВт/ 4MPPT | Оформление каталога (основной)
75 мм Arial | 54 кВт/ 3MPPT | Оформление каталога (основной)
75 мм Arial | 54 кВт/ 4MPPT | Оформление каталога : Оформление каталога
