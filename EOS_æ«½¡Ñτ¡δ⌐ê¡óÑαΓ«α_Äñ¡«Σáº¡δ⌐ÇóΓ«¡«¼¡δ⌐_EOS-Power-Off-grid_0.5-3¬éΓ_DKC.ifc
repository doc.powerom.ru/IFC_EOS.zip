Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-04-23T19:03:04
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181217_1515(x64) - Exporter 19.2.0.65 - Альтернативный интерфейс 19.2.0.65
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Apr 23 19:03:04 2024 * Host: WIN-0P1AU7TJQME * Database: C:\Users\user\AppData\Local\Temp\{268CD7E0-2EF7-4502-8BF4-F848A976FA96}\ifc * Database version: 5507 * Database creation date: Tue Apr 23 19:03:03 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Apr 23 19:03:03 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Apr 23 19:03:03 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2022
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2022
Идентификация - Вариант конструкции: Главная модель
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее(Type) - Категория: Уровни; Имя семейства: Уровень
Идентификация(Type) - Имя типа: Отметка уровня с именем
Зависимости(Type) - Базовая отметка: Базовая точка проекта
Графика(Type) - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: Сплошная; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Зависимости - Фасад: 0 mm
Идентификация - Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Прочее - Категория: Уровни; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: EOS Power Off-grid 0.5 кВ, EOS_СолнечныйИнвертор_ОднофазныйАвтономный_EOS-Power-Off-grid_0.5-3кВт_DKC:EOS Power Off-grid 0.5 кВ:625026
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Серый, DKC_Корпус_Черный, DKC_Корпус_Бежевый
Type - Данные - ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPA0K7D0K5A; ADSK_Количество: 1; ADSK_Марка: EOS Power Off-grid; ADSK_Масса: 17; ADSK_Масса_Текст: 17; ADSK_Материал: DKC_Корпус_Бежевый; ADSK_Наименование: Однофазный автономный солнечный инвертор EOS Power Off-grid 0.5 кВт; ADSK_Наименование краткое: Инвертор EOS Power Off-grid 0.5 кВ
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/a38/bhvm51lc54jy2azubsmuhrz232lk4m6k.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1759/EPA0K7D0K5A/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power Off-grid 0.5 кВ; Описание: Автономные солнечные инверторы используются для создания систем независимого электроснабжения потребителей там, где это необходимо: в доме, коттедже, предприятии и т.д. Аккумулируя и пропуская через инвертор солнечную энергию, вырабатываемую фотоэлектрическими панелями, а также энергию от дополнительных источников питания - сети и дизель-генератора - можно предоставлять эту энергию по мере необходимости потребителям, обеспечивать стабильное штатное и аварийное их питание.
Type - Материалы и отделка - Материал_Корпус: DKC_Корпус_Черный; Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ОднофазныйАвтономный_EOS-Power-Off-grid_0.5-3кВт_DKC; Интерфейсы связи: RS232/USB/RS485 (базовые); SNMP/GPRS (опция); Рабочая температура: 0°С ~ 40°С; Степень защиты: IP 21
Type - Размеры - ADSK_Размер_Высота: 442 mm; ADSK_Размер_Глубина: 210 mm; ADSK_Размер_Ширина: 366 mm
Type - Электросети - Номинальное напряжение АКБ: 12 V; Полная мощность АКБ: 0 W
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 1; ADSK_Количество фаз числовое: 1; ADSK_Коэффициент мощности: 1; ADSK_КПД: 78; ADSK_Напряжение: 230 V; ADSK_Номинальная мощность: 500 W; ADSK_Полная мощность: 500 W; ADSK_Ток: 43 A
Pset_BuildingElementProxyCommon - Reference: EOS Power Off-grid 0.5 кВ
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 25
Прочее - Код типа: EOS_СолнечныйИнвертор_ОднофазныйАвтономный_EOS-Power-Off-grid_0.5-3кВт_DKC: EOS Power Off-grid 0.5 кВ; Семейство: EOS_СолнечныйИнвертор_ОднофазныйАвтономный_EOS-Power-Off-grid_0.5-3кВт_DKC: EOS Power Off-grid 0.5 кВ; Семейство и типоразмер: EOS_СолнечныйИнвертор_ОднофазныйАвтономный_EOS-Power-Off-grid_0.5-3кВт_DKC: EOS Power Off-grid 0.5 кВ; Тип: EOS_СолнечныйИнвертор_ОднофазныйАвтономный_EOS-Power-Off-grid_0.5-3кВт_DKC: EOS Power Off-grid 0.5 кВ
Размеры - Объем: 0.03182 m3; Площадь: 0.315324 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 230 В/1-500 В·А-Подключение АКБ 12 В/1-0 В·А

# IfcBuildingElementProxy: EOS Power Off-grid 1 кВт, EOS_СолнечныйИнвертор_ОднофазныйАвтономный_EOS-Power-Off-grid_0.5-3кВт_DKC:EOS Power Off-grid 1 кВт:625027
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Серый, DKC_Корпус_Черный, DKC_Корпус_Бежевый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Бежевый; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPA1K4D001A; ADSK_Марка: EOS Power Off-grid; ADSK_Масса: 20; ADSK_Масса_Текст: 20; ADSK_Наименование: Однофазный автономный солнечный инвертор EOS Power Off-grid 1 кВт; ADSK_Наименование краткое: Инвертор EOS Power Off-grid 1 кВт
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/a38/bhvm51lc54jy2azubsmuhrz232lk4m6k.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1759/EPA1K4D001A/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power Off-grid 1 кВт; Описание: Автономные солнечные инверторы используются для создания систем независимого электроснабжения потребителей там, где это необходимо: в доме, коттедже, предприятии и т.д. Аккумулируя и пропуская через инвертор солнечную энергию, вырабатываемую фотоэлектрическими панелями, а также энергию от дополнительных источников питания - сети и дизель-генератора - можно предоставлять эту энергию по мере необходимости потребителям, обеспечивать стабильное штатное и аварийное их питание.
Type - Материалы и отделка - Материал_Корпус: DKC_Корпус_Черный; Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ОднофазныйАвтономный_EOS-Power-Off-grid_0.5-3кВт_DKC; Интерфейсы связи: RS232/USB/RS485 (базовые); SNMP/GPRS (опция); Рабочая температура: 0°С ~ 40°С; Степень защиты: IP 21
Type - Размеры - ADSK_Размер_Высота: 442 mm; ADSK_Размер_Глубина: 210 mm; ADSK_Размер_Ширина: 366 mm
Type - Электросети - Номинальное напряжение АКБ: 24 V; Полная мощность АКБ: 0 W
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 1; ADSK_Количество фаз числовое: 1; ADSK_Коэффициент мощности: 1; ADSK_КПД: 82; ADSK_Напряжение: 230 V; ADSK_Номинальная мощность: 1000 W; ADSK_Полная мощность: 1000 W; ADSK_Ток: 43 A
Pset_BuildingElementProxyCommon - Reference: EOS Power Off-grid 1 кВт
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Идентификация - Марка: 26
Прочее - Код типа: EOS_СолнечныйИнвертор_ОднофазныйАвтономный_EOS-Power-Off-grid_0.5-3кВт_DKC: EOS Power Off-grid 1 кВт; Семейство: EOS_СолнечныйИнвертор_ОднофазныйАвтономный_EOS-Power-Off-grid_0.5-3кВт_DKC: EOS Power Off-grid 1 кВт; Семейство и типоразмер: EOS_СолнечныйИнвертор_ОднофазныйАвтономный_EOS-Power-Off-grid_0.5-3кВт_DKC: EOS Power Off-grid 1 кВт; Тип: EOS_СолнечныйИнвертор_ОднофазныйАвтономный_EOS-Power-Off-grid_0.5-3кВт_DKC: EOS Power Off-grid 1 кВт
Размеры - Объем: 0.03182 m3; Площадь: 0.315324 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 230 В/1-1000 В·А-Подключение АКБ 24 В/1-0 В·А

# IfcBuildingElementProxy: EOS Power Off-grid 2 кВт, EOS_СолнечныйИнвертор_ОднофазныйАвтономный_EOS-Power-Off-grid_0.5-3кВт_DKC:EOS Power Off-grid 2 кВт:625028
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Серый, DKC_Корпус_Черный, DKC_Корпус_Бежевый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Бежевый; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPA2K8D002A; ADSK_Марка: EOS Power Off-grid; ADSK_Масса: 31; ADSK_Масса_Текст: 31; ADSK_Наименование: Однофазный автономный солнечный инвертор EOS Power Off-grid 2 кВт; ADSK_Наименование краткое: Инвертор EOS Power Off-grid 2 кВт
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/a38/bhvm51lc54jy2azubsmuhrz232lk4m6k.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1759/EPA2K8D002A/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power Off-grid 2 кВт; Описание: Автономные солнечные инверторы используются для создания систем независимого электроснабжения потребителей там, где это необходимо: в доме, коттедже, предприятии и т.д. Аккумулируя и пропуская через инвертор солнечную энергию, вырабатываемую фотоэлектрическими панелями, а также энергию от дополнительных источников питания - сети и дизель-генератора - можно предоставлять эту энергию по мере необходимости потребителям, обеспечивать стабильное штатное и аварийное их питание.
Type - Материалы и отделка - Материал_Корпус: DKC_Корпус_Черный; Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ОднофазныйАвтономный_EOS-Power-Off-grid_0.5-3кВт_DKC; Интерфейсы связи: RS232/USB/RS485 (базовые); SNMP/GPRS (опция); Рабочая температура: 0°С ~ 40°С; Степень защиты: IP 21
Type - Размеры - ADSK_Размер_Высота: 442 mm; ADSK_Размер_Глубина: 210 mm; ADSK_Размер_Ширина: 366 mm
Type - Электросети - Номинальное напряжение АКБ: 48 V; Полная мощность АКБ: 0 W
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 1; ADSK_Количество фаз числовое: 1; ADSK_Коэффициент мощности: 1; ADSK_КПД: 85; ADSK_Напряжение: 230 V; ADSK_Номинальная мощность: 2000 W; ADSK_Полная мощность: 2000 W; ADSK_Ток: 43 A
Pset_BuildingElementProxyCommon - Reference: EOS Power Off-grid 2 кВт
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 27
Прочее - Код типа: EOS_СолнечныйИнвертор_ОднофазныйАвтономный_EOS-Power-Off-grid_0.5-3кВт_DKC: EOS Power Off-grid 2 кВт; Семейство: EOS_СолнечныйИнвертор_ОднофазныйАвтономный_EOS-Power-Off-grid_0.5-3кВт_DKC: EOS Power Off-grid 2 кВт; Семейство и типоразмер: EOS_СолнечныйИнвертор_ОднофазныйАвтономный_EOS-Power-Off-grid_0.5-3кВт_DKC: EOS Power Off-grid 2 кВт; Тип: EOS_СолнечныйИнвертор_ОднофазныйАвтономный_EOS-Power-Off-grid_0.5-3кВт_DKC: EOS Power Off-grid 2 кВт
Размеры - Объем: 0.03182 m3; Площадь: 0.315324 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 230 В/1-2000 В·А-Подключение АКБ 48 В/1-0 В·А

# IfcBuildingElementProxy: EOS Power Off-grid 3 кВт, EOS_СолнечныйИнвертор_ОднофазныйАвтономный_EOS-Power-Off-grid_0.5-3кВт_DKC:EOS Power Off-grid 3 кВт:625029
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Серый, DKC_Корпус_Черный, DKC_Корпус_Бежевый
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Бежевый; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPA3K5D003A; ADSK_Марка: EOS Power Off-grid; ADSK_Масса: 39; ADSK_Масса_Текст: 39; ADSK_Наименование: Однофазный автономный солнечный инвертор EOS Power Off-grid 3 кВт; ADSK_Наименование краткое: Инвертор EOS Power Off-grid 3 кВт
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/a38/bhvm51lc54jy2azubsmuhrz232lk4m6k.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1759/EPA3K5D003A/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power Off-grid 3 кВт; Описание: Автономные солнечные инверторы используются для создания систем независимого электроснабжения потребителей там, где это необходимо: в доме, коттедже, предприятии и т.д. Аккумулируя и пропуская через инвертор солнечную энергию, вырабатываемую фотоэлектрическими панелями, а также энергию от дополнительных источников питания - сети и дизель-генератора - можно предоставлять эту энергию по мере необходимости потребителям, обеспечивать стабильное штатное и аварийное их питание.
Type - Материалы и отделка - Материал_Корпус: DKC_Корпус_Черный; Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ОднофазныйАвтономный_EOS-Power-Off-grid_0.5-3кВт_DKC; Интерфейсы связи: RS232/USB/RS485 (базовые); SNMP/GPRS (опция); Рабочая температура: 0°С ~ 40°С; Степень защиты: IP 21
Type - Размеры - ADSK_Размер_Высота: 442 mm; ADSK_Размер_Глубина: 210 mm; ADSK_Размер_Ширина: 366 mm
Type - Электросети - Номинальное напряжение АКБ: 48 V; Полная мощность АКБ: 0 W
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 1; ADSK_Количество фаз числовое: 1; ADSK_Коэффициент мощности: 1; ADSK_КПД: 85; ADSK_Напряжение: 230 V; ADSK_Номинальная мощность: 3000 W; ADSK_Полная мощность: 3000 W; ADSK_Ток: 53 A
Pset_BuildingElementProxyCommon - Reference: EOS Power Off-grid 3 кВт
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 28
Прочее - Код типа: EOS_СолнечныйИнвертор_ОднофазныйАвтономный_EOS-Power-Off-grid_0.5-3кВт_DKC: EOS Power Off-grid 3 кВт; Семейство: EOS_СолнечныйИнвертор_ОднофазныйАвтономный_EOS-Power-Off-grid_0.5-3кВт_DKC: EOS Power Off-grid 3 кВт; Семейство и типоразмер: EOS_СолнечныйИнвертор_ОднофазныйАвтономный_EOS-Power-Off-grid_0.5-3кВт_DKC: EOS Power Off-grid 3 кВт; Тип: EOS_СолнечныйИнвертор_ОднофазныйАвтономный_EOS-Power-Off-grid_0.5-3кВт_DKC: EOS Power Off-grid 3 кВт
Размеры - Объем: 0.03182 m3; Площадь: 0.315324 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 230 В/1-3000 В·А-Подключение АКБ 48 В/1-0 В·А

# IfcBuildingElementProxy: Текст модели:75 мм Arial (4)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 75 мм Arial
Графика - Горизонтальное выравнивание: По центру
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Вариант конструкции: Оформление каталога : Оформление каталога; Подкатегория: Обобщенные модели
Материалы и отделка - Материал: DKC_СерыйЛого
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 75 мм Arial; Семейство: Текст модели: 75 мм Arial; Семейство и типоразмер: Текст модели: 75 мм Arial; Тип: Текст модели: 75 мм Arial
Размеры - Глубина:: 5 mm
Стадии - Стадия возведения: Стадия 1
Идентификация(Type) - Имя типа: 75 мм Arial
Прочее(Type) - Категория: Обобщенные модели; Имя семейства: Текст модели
Текст(Type) - Жирный: no; Курсив: no; Размер текста: 75 mm; Шрифт текста: Arial
Name (Текст модели:...) | Текст
75 мм Arial | 0,5 кВт
75 мм Arial | 1 кВт
75 мм Arial | 2 кВт
75 мм Arial | 3 кВт
