Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-04-23T18:53:32
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181217_1515(x64) - Exporter 19.2.0.65 - Альтернативный интерфейс 19.2.0.65
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Apr 23 18:53:32 2024 * Host: WIN-0P1AU7TJQME * Database: C:\Users\user\AppData\Local\Temp\{8EB342D7-52C3-463F-83A9-A8AEC1C90230}\ifc * Database version: 5507 * Database creation date: Tue Apr 23 18:53:30 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Apr 23 18:53:30 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Apr 23 18:53:30 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2022
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2022
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее(Type) - Категория: Уровни; Имя семейства: Уровень
Идентификация(Type) - Имя типа: Отметка уровня с именем
Зависимости(Type) - Базовая отметка: Базовая точка проекта
Графика(Type) - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: Сплошная; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Зависимости - Фасад: 0 mm
Идентификация - Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Прочее - Категория: Уровни; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: EOS Power Off-grid 108 кВт/6MPPT, EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC:EOS Power Off-grid 108 кВт/6MPPT:625051
In: Этаж 01
Type - Material: DKC_Корпус_Светло-серый, DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Решетка-Соты_Черный
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPA150D108A; ADSK_Марка: EOS Power Off-grid; ADSK_Масса: 840; ADSK_Масса_Текст: 840; ADSK_Наименование: Трехфазный солнечный инвертор EOS Power Off-grid 108 кВт/6MPPT; ADSK_Наименование краткое: Инвертор EOS Power Off-grid 108 кВт/6MPPT
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/72b/resia6gep1pqefg0cc9k1rsdxfa1alqe.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1759/EPA150D108A/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power Off-grid 108 кВт/6MPPT; Описание: Автономные солнечные инверторы используются для создания систем независимого электроснабжения потребителей там, где это необходимо: в доме, коттедже, предприятии и т.д. Аккумулируя и пропуская через инвертор солнечную энергию, вырабатываемую фотоэлектрическими панелями, а также энергию от дополнительных источников питания - сети и дизель-генератора - можно предоставлять эту энергию по мере необходимости потребителям, обеспечивать стабильное штатное и аварийное их питание.
Type - Материалы и отделка - Материал_Зона обслуживания: DKC_Зона обслуживания; Материал_Логотип: DKC_Корпус_Красный; Материал_Панель управления: DKC_Корпус_Черный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC; Интерфейсы связи: RS232/RS485/USB/реле (базовые); SNMP/Wi-Fi/GPRS (опция); Рабочая температура: 0°С ~ 40°С; Степень защиты: IP 20
Type - Размеры - ADSK_Размер_Высота: 1700 mm; ADSK_Размер_Глубина: 800 mm; ADSK_Размер_Ширина: 960 mm
Type - Электросети - Номинальное напряжение АКБ: 360 V; Полная мощность АКБ: 0 W
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Коэффициент мощности: 0.9; ADSK_КПД: 93; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 108000 W; ADSK_Полная мощность: 120000 W; ADSK_Ток: 360 A
Pset_BuildingElementProxyCommon - Reference: EOS Power Off-grid 108 кВт/6MPPT
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - ADSK_Зона обслуживания: yes
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 95
Прочее - Код типа: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 108 кВт/6MPPT; Семейство: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 108 кВт/6MPPT; Семейство и типоразмер: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 108 кВт/6MPPT; Тип: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 108 кВт/6MPPT
Размеры - Объем: 4.9536 m3; Площадь: 13.992 m2
Свойства модели - Размер_Глубина ЗО_Сбоку: 1000 mm; Размер_Глубина ЗО_Сверху: 500 mm
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-120000 В·А-Подключение АКБ 360 В/3-0 В·А

# IfcBuildingElementProxy: EOS Power Off-grid 108 кВт/7MPPT, EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC:EOS Power Off-grid 108 кВт/7MPPT:625052
In: Этаж 01
Type - Material: DKC_Корпус_Светло-серый, DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Решетка-Соты_Черный
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPA175D108A; ADSK_Марка: EOS Power Off-grid; ADSK_Масса: 846; ADSK_Масса_Текст: 846; ADSK_Наименование: Трехфазный солнечный инвертор EOS Power Off-grid 108 кВт/7MPPT; ADSK_Наименование краткое: Инвертор EOS Power Off-grid 108 кВт/7MPPT
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/72b/resia6gep1pqefg0cc9k1rsdxfa1alqe.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1759/EPA175D108A/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power Off-grid 108 кВт/7MPPT; Описание: Автономные солнечные инверторы используются для создания систем независимого электроснабжения потребителей там, где это необходимо: в доме, коттедже, предприятии и т.д. Аккумулируя и пропуская через инвертор солнечную энергию, вырабатываемую фотоэлектрическими панелями, а также энергию от дополнительных источников питания - сети и дизель-генератора - можно предоставлять эту энергию по мере необходимости потребителям, обеспечивать стабильное штатное и аварийное их питание.
Type - Материалы и отделка - Материал_Зона обслуживания: DKC_Зона обслуживания; Материал_Логотип: DKC_Корпус_Красный; Материал_Панель управления: DKC_Корпус_Черный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC; Интерфейсы связи: RS232/RS485/USB/реле (базовые); SNMP/Wi-Fi/GPRS (опция); Рабочая температура: 0°С ~ 40°С; Степень защиты: IP 20
Type - Размеры - ADSK_Размер_Высота: 1700 mm; ADSK_Размер_Глубина: 800 mm; ADSK_Размер_Ширина: 960 mm
Type - Электросети - Номинальное напряжение АКБ: 360 V; Полная мощность АКБ: 0 W
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Коэффициент мощности: 0.9; ADSK_КПД: 93; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 108000 W; ADSK_Полная мощность: 120000 W; ADSK_Ток: 420 A
Pset_BuildingElementProxyCommon - Reference: EOS Power Off-grid 108 кВт/7MPPT
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - ADSK_Зона обслуживания: yes
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 96
Прочее - Код типа: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 108 кВт/7MPPT; Семейство: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 108 кВт/7MPPT; Семейство и типоразмер: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 108 кВт/7MPPT; Тип: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 108 кВт/7MPPT
Размеры - Объем: 4.9536 m3; Площадь: 13.992 m2
Свойства модели - Размер_Глубина ЗО_Сбоку: 1000 mm; Размер_Глубина ЗО_Сверху: 500 mm
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-120000 В·А-Подключение АКБ 360 В/3-0 В·А

# IfcBuildingElementProxy: EOS Power Off-grid 108 кВт/8MPPT, EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC:EOS Power Off-grid 108 кВт/8MPPT:625053
In: Этаж 01
Type - Material: DKC_Корпус_Светло-серый, DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Решетка-Соты_Черный
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPA200D108A; ADSK_Марка: EOS Power Off-grid; ADSK_Масса: 852; ADSK_Масса_Текст: 852; ADSK_Наименование: Трехфазный солнечный инвертор EOS Power Off-grid 108 кВт/8MPPT; ADSK_Наименование краткое: Инвертор EOS Power Off-grid 108 кВт/8MPPT
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/72b/resia6gep1pqefg0cc9k1rsdxfa1alqe.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1759/EPA200D108A/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power Off-grid 108 кВт/8MPPT; Описание: Автономные солнечные инверторы используются для создания систем независимого электроснабжения потребителей там, где это необходимо: в доме, коттедже, предприятии и т.д. Аккумулируя и пропуская через инвертор солнечную энергию, вырабатываемую фотоэлектрическими панелями, а также энергию от дополнительных источников питания - сети и дизель-генератора - можно предоставлять эту энергию по мере необходимости потребителям, обеспечивать стабильное штатное и аварийное их питание.
Type - Материалы и отделка - Материал_Зона обслуживания: DKC_Зона обслуживания; Материал_Логотип: DKC_Корпус_Красный; Материал_Панель управления: DKC_Корпус_Черный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC; Интерфейсы связи: RS232/RS485/USB/реле (базовые); SNMP/Wi-Fi/GPRS (опция); Рабочая температура: 0°С ~ 40°С; Степень защиты: IP 20
Type - Размеры - ADSK_Размер_Высота: 1700 mm; ADSK_Размер_Глубина: 800 mm; ADSK_Размер_Ширина: 960 mm
Type - Электросети - Номинальное напряжение АКБ: 360 V; Полная мощность АКБ: 0 W
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Коэффициент мощности: 0.9; ADSK_КПД: 93; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 108000 W; ADSK_Полная мощность: 120000 W; ADSK_Ток: 480 A
Pset_BuildingElementProxyCommon - Reference: EOS Power Off-grid 108 кВт/8MPPT
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - ADSK_Зона обслуживания: yes
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 97
Прочее - Код типа: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 108 кВт/8MPPT; Семейство: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 108 кВт/8MPPT; Семейство и типоразмер: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 108 кВт/8MPPT; Тип: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 108 кВт/8MPPT
Размеры - Объем: 4.9536 m3; Площадь: 13.992 m2
Свойства модели - Размер_Глубина ЗО_Сбоку: 1000 mm; Размер_Глубина ЗО_Сверху: 500 mm
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-120000 В·А-Подключение АКБ 360 В/3-0 В·А

# IfcBuildingElementProxy: EOS Power Off-grid 72 кВт/4MPPT, EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC:EOS Power Off-grid 72 кВт/4MPPT:625042
In: Этаж 01
Type - Material: DKC_Корпус_Светло-серый, DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Решетка-Соты_Черный
Type - Данные - ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPA100D072A; ADSK_Количество: 1; ADSK_Марка: EOS Power Off-grid; ADSK_Масса: 828; ADSK_Масса_Текст: 828; ADSK_Материал: DKC_Корпус_Черный; ADSK_Наименование: Трехфазный солнечный инвертор EOS Power Off-grid 72 кВт/4MPPT; ADSK_Наименование краткое: Инвертор EOS Power Off-grid 72 кВт/4MPPT
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/72b/resia6gep1pqefg0cc9k1rsdxfa1alqe.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1759/EPA100D072A/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power Off-grid 72 кВт/4MPPT; Описание: Автономные солнечные инверторы используются для создания систем независимого электроснабжения потребителей там, где это необходимо: в доме, коттедже, предприятии и т.д. Аккумулируя и пропуская через инвертор солнечную энергию, вырабатываемую фотоэлектрическими панелями, а также энергию от дополнительных источников питания - сети и дизель-генератора - можно предоставлять эту энергию по мере необходимости потребителям, обеспечивать стабильное штатное и аварийное их питание.
Type - Материалы и отделка - Материал_Зона обслуживания: DKC_Зона обслуживания; Материал_Логотип: DKC_Корпус_Красный; Материал_Панель управления: DKC_Корпус_Черный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC; Интерфейсы связи: RS232/RS485/USB/реле (базовые); SNMP/Wi-Fi/GPRS (опция); Рабочая температура: 0°С ~ 40°С; Степень защиты: IP 20
Type - Размеры - ADSK_Размер_Высота: 1700 mm; ADSK_Размер_Глубина: 800 mm; ADSK_Размер_Ширина: 960 mm
Type - Электросети - Номинальное напряжение АКБ: 360 V; Полная мощность АКБ: 0 W
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Коэффициент мощности: 0.9; ADSK_КПД: 93; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 72000 W; ADSK_Полная мощность: 80000 W; ADSK_Ток: 240 A
Pset_BuildingElementProxyCommon - Reference: EOS Power Off-grid 72 кВт/4MPPT
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - ADSK_Зона обслуживания: yes
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Марка: 72
Прочее - Код типа: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 72 кВт/4MPPT; Семейство: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 72 кВт/4MPPT; Семейство и типоразмер: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 72 кВт/4MPPT; Тип: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 72 кВт/4MPPT
Размеры - Объем: 4.9536 m3; Площадь: 13.992 m2
Свойства модели - Размер_Глубина ЗО_Сбоку: 1000 mm; Размер_Глубина ЗО_Сверху: 500 mm
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-80000 В·А-Подключение АКБ 360 В/3-0 В·А

# IfcBuildingElementProxy: EOS Power Off-grid 72 кВт/5MPPT, EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC:EOS Power Off-grid 72 кВт/5MPPT:625043
In: Этаж 01
Type - Material: DKC_Корпус_Светло-серый, DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Решетка-Соты_Черный
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPA125D072A; ADSK_Марка: EOS Power Off-grid; ADSK_Масса: 834; ADSK_Масса_Текст: 834; ADSK_Наименование: Трехфазный солнечный инвертор EOS Power Off-grid 72 кВт/5MPPT; ADSK_Наименование краткое: Инвертор EOS Power Off-grid 72 кВт/5MPPT
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/72b/resia6gep1pqefg0cc9k1rsdxfa1alqe.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1759/EPA125D072A/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power Off-grid 72 кВт/5MPPT; Описание: Автономные солнечные инверторы используются для создания систем независимого электроснабжения потребителей там, где это необходимо: в доме, коттедже, предприятии и т.д. Аккумулируя и пропуская через инвертор солнечную энергию, вырабатываемую фотоэлектрическими панелями, а также энергию от дополнительных источников питания - сети и дизель-генератора - можно предоставлять эту энергию по мере необходимости потребителям, обеспечивать стабильное штатное и аварийное их питание.
Type - Материалы и отделка - Материал_Зона обслуживания: DKC_Зона обслуживания; Материал_Логотип: DKC_Корпус_Красный; Материал_Панель управления: DKC_Корпус_Черный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC; Интерфейсы связи: RS232/RS485/USB/реле (базовые); SNMP/Wi-Fi/GPRS (опция); Рабочая температура: 0°С ~ 40°С; Степень защиты: IP 20
Type - Размеры - ADSK_Размер_Высота: 1700 mm; ADSK_Размер_Глубина: 800 mm; ADSK_Размер_Ширина: 960 mm
Type - Электросети - Номинальное напряжение АКБ: 360 V; Полная мощность АКБ: 0 W
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Коэффициент мощности: 0.9; ADSK_КПД: 93; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 72000 W; ADSK_Полная мощность: 80000 W; ADSK_Ток: 300 A
Pset_BuildingElementProxyCommon - Reference: EOS Power Off-grid 72 кВт/5MPPT
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - ADSK_Зона обслуживания: yes
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Идентификация - Марка: 73
Прочее - Код типа: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 72 кВт/5MPPT; Семейство: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 72 кВт/5MPPT; Семейство и типоразмер: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 72 кВт/5MPPT; Тип: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 72 кВт/5MPPT
Размеры - Объем: 4.9536 m3; Площадь: 13.992 m2
Свойства модели - Размер_Глубина ЗО_Сбоку: 1000 mm; Размер_Глубина ЗО_Сверху: 500 mm
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-80000 В·А-Подключение АКБ 360 В/3-0 В·А

# IfcBuildingElementProxy: EOS Power Off-grid 72 кВт/6MPPT, EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC:EOS Power Off-grid 72 кВт/6MPPT:625044
In: Этаж 01
Type - Material: DKC_Корпус_Светло-серый, DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Решетка-Соты_Черный
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPA150D072A; ADSK_Марка: EOS Power Off-grid; ADSK_Масса: 840; ADSK_Масса_Текст: 840; ADSK_Наименование: Трехфазный солнечный инвертор EOS Power Off-grid 72 кВт/6MPPT; ADSK_Наименование краткое: Инвертор EOS Power Off-grid 72 кВт/6MPPT
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/72b/resia6gep1pqefg0cc9k1rsdxfa1alqe.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1759/EPA150D072A/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power Off-grid 72 кВт/6MPPT; Описание: Автономные солнечные инверторы используются для создания систем независимого электроснабжения потребителей там, где это необходимо: в доме, коттедже, предприятии и т.д. Аккумулируя и пропуская через инвертор солнечную энергию, вырабатываемую фотоэлектрическими панелями, а также энергию от дополнительных источников питания - сети и дизель-генератора - можно предоставлять эту энергию по мере необходимости потребителям, обеспечивать стабильное штатное и аварийное их питание.
Type - Материалы и отделка - Материал_Зона обслуживания: DKC_Зона обслуживания; Материал_Логотип: DKC_Корпус_Красный; Материал_Панель управления: DKC_Корпус_Черный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC; Интерфейсы связи: RS232/RS485/USB/реле (базовые); SNMP/Wi-Fi/GPRS (опция); Рабочая температура: 0°С ~ 40°С; Степень защиты: IP 20
Type - Размеры - ADSK_Размер_Высота: 1700 mm; ADSK_Размер_Глубина: 800 mm; ADSK_Размер_Ширина: 960 mm
Type - Электросети - Номинальное напряжение АКБ: 360 V; Полная мощность АКБ: 0 W
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Коэффициент мощности: 0.9; ADSK_КПД: 93; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 72000 W; ADSK_Полная мощность: 80000 W; ADSK_Ток: 360 A
Pset_BuildingElementProxyCommon - Reference: EOS Power Off-grid 72 кВт/6MPPT
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - ADSK_Зона обслуживания: yes
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 88
Прочее - Код типа: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 72 кВт/6MPPT; Семейство: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 72 кВт/6MPPT; Семейство и типоразмер: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 72 кВт/6MPPT; Тип: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 72 кВт/6MPPT
Размеры - Объем: 4.9536 m3; Площадь: 13.992 m2
Свойства модели - Размер_Глубина ЗО_Сбоку: 1000 mm; Размер_Глубина ЗО_Сверху: 500 mm
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-80000 В·А-Подключение АКБ 360 В/3-0 В·А

# IfcBuildingElementProxy: EOS Power Off-grid 72 кВт/7MPPT, EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC:EOS Power Off-grid 72 кВт/7MPPT:625045
In: Этаж 01
Type - Material: DKC_Корпус_Светло-серый, DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Решетка-Соты_Черный
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPA175D072A; ADSK_Марка: EOS Power Off-grid; ADSK_Масса: 846; ADSK_Масса_Текст: 846; ADSK_Наименование: Трехфазный солнечный инвертор EOS Power Off-grid 72 кВт/7MPPT; ADSK_Наименование краткое: Инвертор EOS Power Off-grid 72 кВт/7MPPT
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/72b/resia6gep1pqefg0cc9k1rsdxfa1alqe.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1759/EPA175D072A/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power Off-grid 72 кВт/7MPPT; Описание: Автономные солнечные инверторы используются для создания систем независимого электроснабжения потребителей там, где это необходимо: в доме, коттедже, предприятии и т.д. Аккумулируя и пропуская через инвертор солнечную энергию, вырабатываемую фотоэлектрическими панелями, а также энергию от дополнительных источников питания - сети и дизель-генератора - можно предоставлять эту энергию по мере необходимости потребителям, обеспечивать стабильное штатное и аварийное их питание.
Type - Материалы и отделка - Материал_Зона обслуживания: DKC_Зона обслуживания; Материал_Логотип: DKC_Корпус_Красный; Материал_Панель управления: DKC_Корпус_Черный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC; Интерфейсы связи: RS232/RS485/USB/реле (базовые); SNMP/Wi-Fi/GPRS (опция); Рабочая температура: 0°С ~ 40°С; Степень защиты: IP 20
Type - Размеры - ADSK_Размер_Высота: 1700 mm; ADSK_Размер_Глубина: 800 mm; ADSK_Размер_Ширина: 960 mm
Type - Электросети - Номинальное напряжение АКБ: 360 V; Полная мощность АКБ: 0 W
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Коэффициент мощности: 0.9; ADSK_КПД: 93; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 72000 W; ADSK_Полная мощность: 80000 W; ADSK_Ток: 420 A
Pset_BuildingElementProxyCommon - Reference: EOS Power Off-grid 72 кВт/7MPPT
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - ADSK_Зона обслуживания: yes
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 89
Прочее - Код типа: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 72 кВт/7MPPT; Семейство: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 72 кВт/7MPPT; Семейство и типоразмер: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 72 кВт/7MPPT; Тип: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 72 кВт/7MPPT
Размеры - Объем: 4.9536 m3; Площадь: 13.992 m2
Свойства модели - Размер_Глубина ЗО_Сбоку: 1000 mm; Размер_Глубина ЗО_Сверху: 500 mm
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-80000 В·А-Подключение АКБ 360 В/3-0 В·А

# IfcBuildingElementProxy: EOS Power Off-grid 72 кВт/8MPPT, EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC:EOS Power Off-grid 72 кВт/8MPPT:625046
In: Этаж 01
Type - Material: DKC_Корпус_Светло-серый, DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Решетка-Соты_Черный
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPA200D072A; ADSK_Марка: EOS Power Off-grid; ADSK_Масса: 852; ADSK_Масса_Текст: 852; ADSK_Наименование: Трехфазный солнечный инвертор EOS Power Off-grid 72 кВт/8MPPT; ADSK_Наименование краткое: Инвертор EOS Power Off-grid 72 кВт/8MPPT
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/72b/resia6gep1pqefg0cc9k1rsdxfa1alqe.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1759/EPA200D072A/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power Off-grid 72 кВт/8MPPT; Описание: Автономные солнечные инверторы используются для создания систем независимого электроснабжения потребителей там, где это необходимо: в доме, коттедже, предприятии и т.д. Аккумулируя и пропуская через инвертор солнечную энергию, вырабатываемую фотоэлектрическими панелями, а также энергию от дополнительных источников питания - сети и дизель-генератора - можно предоставлять эту энергию по мере необходимости потребителям, обеспечивать стабильное штатное и аварийное их питание.
Type - Материалы и отделка - Материал_Зона обслуживания: DKC_Зона обслуживания; Материал_Логотип: DKC_Корпус_Красный; Материал_Панель управления: DKC_Корпус_Черный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC; Интерфейсы связи: RS232/RS485/USB/реле (базовые); SNMP/Wi-Fi/GPRS (опция); Рабочая температура: 0°С ~ 40°С; Степень защиты: IP 20
Type - Размеры - ADSK_Размер_Высота: 1700 mm; ADSK_Размер_Глубина: 800 mm; ADSK_Размер_Ширина: 960 mm
Type - Электросети - Номинальное напряжение АКБ: 360 V; Полная мощность АКБ: 0 W
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Коэффициент мощности: 0.9; ADSK_КПД: 93; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 72000 W; ADSK_Полная мощность: 80000 W; ADSK_Ток: 480 A
Pset_BuildingElementProxyCommon - Reference: EOS Power Off-grid 72 кВт/8MPPT
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - ADSK_Зона обслуживания: yes
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 90
Прочее - Код типа: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 72 кВт/8MPPT; Семейство: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 72 кВт/8MPPT; Семейство и типоразмер: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 72 кВт/8MPPT; Тип: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 72 кВт/8MPPT
Размеры - Объем: 4.9536 m3; Площадь: 13.992 m2
Свойства модели - Размер_Глубина ЗО_Сбоку: 1000 mm; Размер_Глубина ЗО_Сверху: 500 mm
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-80000 В·А-Подключение АКБ 360 В/3-0 В·А

# IfcBuildingElementProxy: EOS Power Off-grid 90 кВт/5MPPT, EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC:EOS Power Off-grid 90 кВт/5MPPT:625047
In: Этаж 01
Type - Material: DKC_Корпус_Светло-серый, DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Решетка-Соты_Черный
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPA125D090A; ADSK_Марка: EOS Power Off-grid; ADSK_Масса: 834; ADSK_Масса_Текст: 834; ADSK_Наименование: Трехфазный солнечный инвертор EOS Power Off-grid 90 кВт/5MPPT; ADSK_Наименование краткое: Инвертор EOS Power Off-grid 90 кВт/5MPPT
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/72b/resia6gep1pqefg0cc9k1rsdxfa1alqe.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1759/EPA125D090A/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power Off-grid 90 кВт/5MPPT; Описание: Автономные солнечные инверторы используются для создания систем независимого электроснабжения потребителей там, где это необходимо: в доме, коттедже, предприятии и т.д. Аккумулируя и пропуская через инвертор солнечную энергию, вырабатываемую фотоэлектрическими панелями, а также энергию от дополнительных источников питания - сети и дизель-генератора - можно предоставлять эту энергию по мере необходимости потребителям, обеспечивать стабильное штатное и аварийное их питание.
Type - Материалы и отделка - Материал_Зона обслуживания: DKC_Зона обслуживания; Материал_Логотип: DKC_Корпус_Красный; Материал_Панель управления: DKC_Корпус_Черный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC; Интерфейсы связи: RS232/RS485/USB/реле (базовые); SNMP/Wi-Fi/GPRS (опция); Рабочая температура: 0°С ~ 40°С; Степень защиты: IP 20
Type - Размеры - ADSK_Размер_Высота: 1700 mm; ADSK_Размер_Глубина: 800 mm; ADSK_Размер_Ширина: 960 mm
Type - Электросети - Номинальное напряжение АКБ: 360 V; Полная мощность АКБ: 0 W
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Коэффициент мощности: 0.9; ADSK_КПД: 93; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 90000 W; ADSK_Полная мощность: 100000 W; ADSK_Ток: 300 A
Pset_BuildingElementProxyCommon - Reference: EOS Power Off-grid 90 кВт/5MPPT
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - ADSK_Зона обслуживания: yes
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 91
Прочее - Код типа: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 90 кВт/5MPPT; Семейство: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 90 кВт/5MPPT; Семейство и типоразмер: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 90 кВт/5MPPT; Тип: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 90 кВт/5MPPT
Размеры - Объем: 4.9536 m3; Площадь: 13.992 m2
Свойства модели - Размер_Глубина ЗО_Сбоку: 1000 mm; Размер_Глубина ЗО_Сверху: 500 mm
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-100000 В·А-Подключение АКБ 360 В/3-0 В·А

# IfcBuildingElementProxy: EOS Power Off-grid 90 кВт/6MPPT, EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC:EOS Power Off-grid 90 кВт/6MPPT:625048
In: Этаж 01
Type - Material: DKC_Корпус_Светло-серый, DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Решетка-Соты_Черный
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPA150D090A; ADSK_Марка: EOS Power Off-grid; ADSK_Масса: 840; ADSK_Масса_Текст: 840; ADSK_Наименование: Трехфазный солнечный инвертор EOS Power Off-grid 90 кВт/6MPPT; ADSK_Наименование краткое: Инвертор EOS Power Off-grid 90 кВт/6MPPT
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/72b/resia6gep1pqefg0cc9k1rsdxfa1alqe.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1759/EPA150D090A/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power Off-grid 90 кВт/6MPPT; Описание: Автономные солнечные инверторы используются для создания систем независимого электроснабжения потребителей там, где это необходимо: в доме, коттедже, предприятии и т.д. Аккумулируя и пропуская через инвертор солнечную энергию, вырабатываемую фотоэлектрическими панелями, а также энергию от дополнительных источников питания - сети и дизель-генератора - можно предоставлять эту энергию по мере необходимости потребителям, обеспечивать стабильное штатное и аварийное их питание.
Type - Материалы и отделка - Материал_Зона обслуживания: DKC_Зона обслуживания; Материал_Логотип: DKC_Корпус_Красный; Материал_Панель управления: DKC_Корпус_Черный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC; Интерфейсы связи: RS232/RS485/USB/реле (базовые); SNMP/Wi-Fi/GPRS (опция); Рабочая температура: 0°С ~ 40°С; Степень защиты: IP 20
Type - Размеры - ADSK_Размер_Высота: 1700 mm; ADSK_Размер_Глубина: 800 mm; ADSK_Размер_Ширина: 960 mm
Type - Электросети - Номинальное напряжение АКБ: 360 V; Полная мощность АКБ: 0 W
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Коэффициент мощности: 0.9; ADSK_КПД: 93; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 90000 W; ADSK_Полная мощность: 100000 W; ADSK_Ток: 360 A
Pset_BuildingElementProxyCommon - Reference: EOS Power Off-grid 90 кВт/6MPPT
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - ADSK_Зона обслуживания: yes
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 92
Прочее - Код типа: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 90 кВт/6MPPT; Семейство: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 90 кВт/6MPPT; Семейство и типоразмер: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 90 кВт/6MPPT; Тип: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 90 кВт/6MPPT
Размеры - Объем: 4.9536 m3; Площадь: 13.992 m2
Свойства модели - Размер_Глубина ЗО_Сбоку: 1000 mm; Размер_Глубина ЗО_Сверху: 500 mm
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-100000 В·А-Подключение АКБ 360 В/3-0 В·А

# IfcBuildingElementProxy: EOS Power Off-grid 90 кВт/7MPPT, EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC:EOS Power Off-grid 90 кВт/7MPPT:625049
In: Этаж 01
Type - Material: DKC_Корпус_Светло-серый, DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Решетка-Соты_Черный
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPA175D090A; ADSK_Марка: EOS Power Off-grid; ADSK_Масса: 846; ADSK_Масса_Текст: 846; ADSK_Наименование: Трехфазный солнечный инвертор EOS Power Off-grid 90 кВт/7MPPT; ADSK_Наименование краткое: Инвертор EOS Power Off-grid 90 кВт/7MPPT
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/72b/resia6gep1pqefg0cc9k1rsdxfa1alqe.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1759/EPA175D090A/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power Off-grid 90 кВт/7MPPT; Описание: Автономные солнечные инверторы используются для создания систем независимого электроснабжения потребителей там, где это необходимо: в доме, коттедже, предприятии и т.д. Аккумулируя и пропуская через инвертор солнечную энергию, вырабатываемую фотоэлектрическими панелями, а также энергию от дополнительных источников питания - сети и дизель-генератора - можно предоставлять эту энергию по мере необходимости потребителям, обеспечивать стабильное штатное и аварийное их питание.
Type - Материалы и отделка - Материал_Зона обслуживания: DKC_Зона обслуживания; Материал_Логотип: DKC_Корпус_Красный; Материал_Панель управления: DKC_Корпус_Черный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC; Интерфейсы связи: RS232/RS485/USB/реле (базовые); SNMP/Wi-Fi/GPRS (опция); Рабочая температура: 0°С ~ 40°С; Степень защиты: IP 20
Type - Размеры - ADSK_Размер_Высота: 1700 mm; ADSK_Размер_Глубина: 800 mm; ADSK_Размер_Ширина: 960 mm
Type - Электросети - Номинальное напряжение АКБ: 360 V; Полная мощность АКБ: 0 W
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Коэффициент мощности: 0.9; ADSK_КПД: 93; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 90000 W; ADSK_Полная мощность: 100000 W; ADSK_Ток: 420 A
Pset_BuildingElementProxyCommon - Reference: EOS Power Off-grid 90 кВт/7MPPT
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - ADSK_Зона обслуживания: yes
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 93
Прочее - Код типа: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 90 кВт/7MPPT; Семейство: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 90 кВт/7MPPT; Семейство и типоразмер: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 90 кВт/7MPPT; Тип: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 90 кВт/7MPPT
Размеры - Объем: 4.9536 m3; Площадь: 13.992 m2
Свойства модели - Размер_Глубина ЗО_Сбоку: 1000 mm; Размер_Глубина ЗО_Сверху: 500 mm
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-100000 В·А-Подключение АКБ 360 В/3-0 В·А

# IfcBuildingElementProxy: EOS Power Off-grid 90 кВт/8MPPT, EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC:EOS Power Off-grid 90 кВт/8MPPT:625050
In: Этаж 01
Type - Material: DKC_Корпус_Светло-серый, DKC_Корпус_Красный, DKC_Корпус_Черный, DKC_Решетка-Соты_Черный
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Черный; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPA200D090A; ADSK_Марка: EOS Power Off-grid; ADSK_Масса: 852; ADSK_Масса_Текст: 852; ADSK_Наименование: Трехфазный солнечный инвертор EOS Power Off-grid 90 кВт/8MPPT; ADSK_Наименование краткое: Инвертор EOS Power Off-grid 90 кВт/8MPPT
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/72b/resia6gep1pqefg0cc9k1rsdxfa1alqe.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1759/EPA200D090A/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power Off-grid 90 кВт/8MPPT; Описание: Автономные солнечные инверторы используются для создания систем независимого электроснабжения потребителей там, где это необходимо: в доме, коттедже, предприятии и т.д. Аккумулируя и пропуская через инвертор солнечную энергию, вырабатываемую фотоэлектрическими панелями, а также энергию от дополнительных источников питания - сети и дизель-генератора - можно предоставлять эту энергию по мере необходимости потребителям, обеспечивать стабильное штатное и аварийное их питание.
Type - Материалы и отделка - Материал_Зона обслуживания: DKC_Зона обслуживания; Материал_Логотип: DKC_Корпус_Красный; Материал_Панель управления: DKC_Корпус_Черный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC; Интерфейсы связи: RS232/RS485/USB/реле (базовые); SNMP/Wi-Fi/GPRS (опция); Рабочая температура: 0°С ~ 40°С; Степень защиты: IP 20
Type - Размеры - ADSK_Размер_Высота: 1700 mm; ADSK_Размер_Глубина: 800 mm; ADSK_Размер_Ширина: 960 mm
Type - Электросети - Номинальное напряжение АКБ: 360 V; Полная мощность АКБ: 0 W
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 3; ADSK_Количество фаз числовое: 3; ADSK_Коэффициент мощности: 0.9; ADSK_КПД: 93; ADSK_Напряжение: 380 V; ADSK_Номинальная мощность: 90000 W; ADSK_Полная мощность: 100000 W; ADSK_Ток: 480 A
Pset_BuildingElementProxyCommon - Reference: EOS Power Off-grid 90 кВт/8MPPT
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Графика - ADSK_Зона обслуживания: yes
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 94
Прочее - Код типа: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 90 кВт/8MPPT; Семейство: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 90 кВт/8MPPT; Семейство и типоразмер: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 90 кВт/8MPPT; Тип: EOS_СолнечныйИнвертор_ТрехфазныйАвтономный_EOS-Power-Off-grid_72-108кВт_DKC: EOS Power Off-grid 90 кВт/8MPPT
Размеры - Объем: 4.9536 m3; Площадь: 13.992 m2
Свойства модели - Размер_Глубина ЗО_Сбоку: 1000 mm; Размер_Глубина ЗО_Сверху: 500 mm
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 380 В/3-100000 В·А-Подключение АКБ 360 В/3-0 В·А

# IfcBuildingElementProxy: Текст модели:75 мм Arial (12)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 75 мм Arial
Графика - Горизонтальное выравнивание: По центру
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели
Материалы и отделка - Материал: DKC_СерыйЛого
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 75 мм Arial; Семейство: Текст модели: 75 мм Arial; Семейство и типоразмер: Текст модели: 75 мм Arial; Тип: Текст модели: 75 мм Arial
Размеры - Глубина:: 5 mm
Стадии - Стадия возведения: Стадия 1
Текст(Type) - Жирный: no; Курсив: no; Размер текста: 75 mm; Шрифт текста: Arial
Прочее(Type) - Категория: Обобщенные модели; Имя семейства: Текст модели
Идентификация(Type) - Имя типа: 75 мм Arial
Name (Текст модели:...) | Текст | Вариант конструкции
75 мм Arial | 72 кВт/ 4MPPT | Оформление каталога (основной)
75 мм Arial | 72 кВт/ 5MPPT | Оформление каталога (основной)
75 мм Arial | 72 кВт/ 6MPPT | Оформление каталога (основной)
75 мм Arial | 72 кВт/ 7MPPT | Оформление каталога (основной)
75 мм Arial | 72 кВт/ 8MPPT | Оформление каталога (основной)
75 мм Arial | 90 кВт/ 5MPPT | Оформление каталога : Оформление каталога
75 мм Arial | 90 кВт/ 6MPPT | Оформление каталога (основной)
75 мм Arial | 90 кВт/ 7MPPT | Оформление каталога : Оформление каталога
75 мм Arial | 90 кВт/ 8MPPT | Оформление каталога (основной)
75 мм Arial | 108 кВт/ 6MPPT | Оформление каталога (основной)
75 мм Arial | 108 кВт/ 7MPPT | Оформление каталога : Оформление каталога
75 мм Arial | 108 кВт/ 8MPPT | Оформление каталога : Оформление каталога
