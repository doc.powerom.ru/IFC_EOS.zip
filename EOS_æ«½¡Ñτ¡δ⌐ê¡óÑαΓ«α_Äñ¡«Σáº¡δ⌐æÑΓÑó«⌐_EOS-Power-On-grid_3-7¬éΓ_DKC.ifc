Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-04-23T19:01:06
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181217_1515(x64) - Exporter 19.2.0.65 - Альтернативный интерфейс 19.2.0.65
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Apr 23 19:01:06 2024 * Host: WIN-0P1AU7TJQME * Database: C:\Users\user\AppData\Local\Temp\{B5AFF83D-E928-44C6-A8E1-28D4600A8C15}\ifc * Database version: 5507 * Database creation date: Tue Apr 23 19:01:05 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Apr 23 19:01:05 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Apr 23 19:01:05 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm
Данные - ADSK_Титул Год выпуска: 2022
Прочее - Категория: Сведения о проекте

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул Год выпуска: 2022
Прочее - Категория: Сведения о проекте

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее(Type) - Категория: Уровни; Имя семейства: Уровень
Идентификация(Type) - Имя типа: Отметка уровня с именем
Зависимости(Type) - Базовая отметка: Базовая точка проекта
Графика(Type) - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: Сплошная; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680
Зависимости - Фасад: 0 mm
Идентификация - Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes
Прочее - Категория: Уровни; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Размеры - Расчетная высота: 0 mm

# IfcBuildingElementProxy: EOS Power On-grid 3 кВт, EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC:EOS Power On-grid 3 кВт:625015
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Светло-серый, DKC_Корпус_Белый, DKC_Корпус_Черный
Type - Данные - ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPG3K9D003A; ADSK_Количество: 1; ADSK_Марка: EOS Power On-grid; ADSK_Масса: 9; ADSK_Масса_Текст: 9; ADSK_Материал: DKC_Корпус_Белый; ADSK_Наименование: Сетевой однофазный солнечный инвертор EOS Power On-grid 3 кВт; ADSK_Наименование краткое: Инвертор EOS Power On-grid 3 кВт
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/583/2t7no00easa0gpt82ziqpr9pb36bs28j.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1740/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power On-grid 3 кВт; Описание: Сетевыми (on-grid) инверторами являются устройства, преобразующие постоянное (DC) напряжение от солнечных панелей в переменное (AC) напряжение, и передающие его напрямую в сеть 220 (или 380) В, с надлежащими значениями частоты и фазы для сопряжения со стационарной сетью, тем самым снижая потребление электроэнергии от энергосетей.
Type - Материалы и отделка - Материал_Дисплей: DKC_Корпус_Черный; Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC; Интерфейсы связи: RS485, Wi-Fi / Ethernet (опционально), GPRS (опционально); Рабочая температура: - 25°С ~ 60°С; Степень защиты: IP 65
Type - Размеры - ADSK_Размер_Высота: 353 mm; ADSK_Размер_Глубина: 116.5 mm; ADSK_Размер_Ширина: 308 mm
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 1; ADSK_Количество фаз числовое: 1; ADSK_Коэффициент мощности: 0.99; ADSK_КПД: 97.3; ADSK_Напряжение: 230 V; ADSK_Номинальная мощность: 3000 W; ADSK_Полная мощность: 3030.3 W; ADSK_Ток: 15 A
Pset_BuildingElementProxyCommon - Reference: EOS Power On-grid 3 кВт
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Основа: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01
Идентификация - Марка: 1
Прочее - Код типа: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC: EOS Power On-grid 3 кВт; Семейство: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC: EOS Power On-grid 3 кВт; Семейство и типоразмер: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC: EOS Power On-grid 3 кВт; Тип: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC: EOS Power On-grid 3 кВт
Размеры - Объем: 0.0156019 m3; Площадь: 0.203577 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 230 В/1-3030 В·А

# IfcBuildingElementProxy: EOS Power On-grid 3,6 кВт, EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC:EOS Power On-grid 3,6 кВт:625016
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Светло-серый, DKC_Корпус_Белый, DKC_Корпус_Черный
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Белый; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPG4K8D3K6A; ADSK_Марка: EOS Power On-grid; ADSK_Масса: 10.9; ADSK_Масса_Текст: 10.9; ADSK_Наименование: Сетевой однофазный солнечный инвертор EOS Power On-grid 3,6 кВт; ADSK_Наименование краткое: Инвертор EOS Power On-grid 3,6 кВт
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/583/2t7no00easa0gpt82ziqpr9pb36bs28j.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1740/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power On-grid 3,6 кВт; Описание: Сетевыми (on-grid) инверторами являются устройства, преобразующие постоянное (DC) напряжение от солнечных панелей в переменное (AC) напряжение, и передающие его напрямую в сеть 220 (или 380) В, с надлежащими значениями частоты и фазы для сопряжения со стационарной сетью, тем самым снижая потребление электроэнергии от энергосетей.
Type - Материалы и отделка - Материал_Дисплей: DKC_Корпус_Черный; Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC; Интерфейсы связи: RS485, Wi-Fi / Ethernet (опционально), GPRS (опционально); Рабочая температура: - 25°С ~ 60°С; Степень защиты: IP 65
Type - Размеры - ADSK_Размер_Высота: 420 mm; ADSK_Размер_Глубина: 126.5 mm; ADSK_Размер_Ширина: 370 mm
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 1; ADSK_Количество фаз числовое: 1; ADSK_Коэффициент мощности: 0.99; ADSK_КПД: 97.3; ADSK_Напряжение: 230 V; ADSK_Номинальная мощность: 3680 W; ADSK_Полная мощность: 3717.17 W; ADSK_Ток: 30 A
Pset_BuildingElementProxyCommon - Reference: EOS Power On-grid 3,6 кВт
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Смещение: 0 mm; Основа: Уровень : Этаж 01; Уровень: Уровень: Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 3
Прочее - Код типа: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC: EOS Power On-grid 3,6 кВт; Семейство: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC: EOS Power On-grid 3,6 кВт; Семейство и типоразмер: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC: EOS Power On-grid 3,6 кВт; Тип: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC: EOS Power On-grid 3,6 кВт
Размеры - Объем: 0.0238539 m3; Площадь: 0.276665 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 230 В/1-3717 В·А

# IfcBuildingElementProxy: EOS Power On-grid 4 кВт, EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC:EOS Power On-grid 4 кВт:625017
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Светло-серый, DKC_Корпус_Белый, DKC_Корпус_Черный
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Белый; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPG5K2D004A; ADSK_Марка: EOS Power On-grid; ADSK_Масса: 10.9; ADSK_Масса_Текст: 10.9; ADSK_Наименование: Сетевой однофазный солнечный инвертор EOS Power On-grid 4 кВт; ADSK_Наименование краткое: Инвертор EOS Power On-grid 4 кВт
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/583/2t7no00easa0gpt82ziqpr9pb36bs28j.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1740/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power On-grid 4 кВт; Описание: Сетевыми (on-grid) инверторами являются устройства, преобразующие постоянное (DC) напряжение от солнечных панелей в переменное (AC) напряжение, и передающие его напрямую в сеть 220 (или 380) В, с надлежащими значениями частоты и фазы для сопряжения со стационарной сетью, тем самым снижая потребление электроэнергии от энергосетей.
Type - Материалы и отделка - Материал_Дисплей: DKC_Корпус_Черный; Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC; Интерфейсы связи: RS485, Wi-Fi / Ethernet (опционально), GPRS (опционально); Рабочая температура: - 25°С ~ 60°С; Степень защиты: IP 65
Type - Размеры - ADSK_Размер_Высота: 420 mm; ADSK_Размер_Глубина: 126.5 mm; ADSK_Размер_Ширина: 370 mm
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 1; ADSK_Количество фаз числовое: 1; ADSK_Коэффициент мощности: 0.99; ADSK_КПД: 97.3; ADSK_Напряжение: 230 V; ADSK_Номинальная мощность: 4000 W; ADSK_Полная мощность: 4040.4 W; ADSK_Ток: 30 A
Pset_BuildingElementProxyCommon - Reference: EOS Power On-grid 4 кВт
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 4
Прочее - Код типа: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC: EOS Power On-grid 4 кВт; Семейство: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC: EOS Power On-grid 4 кВт; Семейство и типоразмер: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC: EOS Power On-grid 4 кВт; Тип: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC: EOS Power On-grid 4 кВт
Размеры - Объем: 0.0238539 m3; Площадь: 0.276665 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 230 В/1-4040 В·А

# IfcBuildingElementProxy: EOS Power On-grid 4,6 кВт, EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC:EOS Power On-grid 4,6 кВт:625018
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Светло-серый, DKC_Корпус_Белый, DKC_Корпус_Черный
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Белый; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPG006D4K6A; ADSK_Марка: EOS Power On-grid; ADSK_Масса: 10.9; ADSK_Масса_Текст: 10.9; ADSK_Наименование: Сетевой однофазный солнечный инвертор EOS Power On-grid 4,6 кВт; ADSK_Наименование краткое: Инвертор EOS Power On-grid 4,6 кВт
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/583/2t7no00easa0gpt82ziqpr9pb36bs28j.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1740/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power On-grid 4,6 кВт; Описание: Сетевыми (on-grid) инверторами являются устройства, преобразующие постоянное (DC) напряжение от солнечных панелей в переменное (AC) напряжение, и передающие его напрямую в сеть 220 (или 380) В, с надлежащими значениями частоты и фазы для сопряжения со стационарной сетью, тем самым снижая потребление электроэнергии от энергосетей.
Type - Материалы и отделка - Материал_Дисплей: DKC_Корпус_Черный; Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC; Интерфейсы связи: RS485, Wi-Fi / Ethernet (опционально), GPRS (опционально); Рабочая температура: - 25°С ~ 60°С; Степень защиты: IP 65
Type - Размеры - ADSK_Размер_Высота: 420 mm; ADSK_Размер_Глубина: 126.5 mm; ADSK_Размер_Ширина: 370 mm
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 1; ADSK_Количество фаз числовое: 1; ADSK_Коэффициент мощности: 0.99; ADSK_КПД: 97.3; ADSK_Напряжение: 230 V; ADSK_Номинальная мощность: 4600 W; ADSK_Полная мощность: 4646.46 W; ADSK_Ток: 30 A
Pset_BuildingElementProxyCommon - Reference: EOS Power On-grid 4,6 кВт
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 5
Прочее - Код типа: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC: EOS Power On-grid 4,6 кВт; Семейство: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC: EOS Power On-grid 4,6 кВт; Семейство и типоразмер: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC: EOS Power On-grid 4,6 кВт; Тип: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC: EOS Power On-grid 4,6 кВт
Размеры - Объем: 0.0238539 m3; Площадь: 0.276665 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 230 В/1-4646 В·А

# IfcBuildingElementProxy: EOS Power On-grid 5 кВт, EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC:EOS Power On-grid 5 кВт:625019
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Светло-серый, DKC_Корпус_Белый, DKC_Корпус_Черный
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Белый; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPG6K5D005A; ADSK_Марка: EOS Power On-grid; ADSK_Масса: 10.9; ADSK_Масса_Текст: 10.9; ADSK_Наименование: Сетевой однофазный солнечный инвертор EOS Power On-grid 5 кВт; ADSK_Наименование краткое: Инвертор EOS Power On-grid 5 кВт
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/583/2t7no00easa0gpt82ziqpr9pb36bs28j.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1740/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power On-grid 5 кВт; Описание: Сетевыми (on-grid) инверторами являются устройства, преобразующие постоянное (DC) напряжение от солнечных панелей в переменное (AC) напряжение, и передающие его напрямую в сеть 220 (или 380) В, с надлежащими значениями частоты и фазы для сопряжения со стационарной сетью, тем самым снижая потребление электроэнергии от энергосетей.
Type - Материалы и отделка - Материал_Дисплей: DKC_Корпус_Черный; Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC; Интерфейсы связи: RS485, Wi-Fi / Ethernet (опционально), GPRS (опционально); Рабочая температура: - 25°С ~ 60°С; Степень защиты: IP 65
Type - Размеры - ADSK_Размер_Высота: 420 mm; ADSK_Размер_Глубина: 126.5 mm; ADSK_Размер_Ширина: 370 mm
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 1; ADSK_Количество фаз числовое: 1; ADSK_Коэффициент мощности: 0.99; ADSK_КПД: 97.3; ADSK_Напряжение: 230 V; ADSK_Номинальная мощность: 5000 W; ADSK_Полная мощность: 5050.51 W; ADSK_Ток: 30 A
Pset_BuildingElementProxyCommon - Reference: EOS Power On-grid 5 кВт
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Вариант конструкции: Главная модель; Марка: 6
Прочее - Код типа: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC: EOS Power On-grid 5 кВт; Семейство: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC: EOS Power On-grid 5 кВт; Семейство и типоразмер: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC: EOS Power On-grid 5 кВт; Тип: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC: EOS Power On-grid 5 кВт
Размеры - Объем: 0.0238539 m3; Площадь: 0.276665 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 230 В/1-5051 В·А

# IfcBuildingElementProxy: EOS Power On-grid 6 кВт, EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC:EOS Power On-grid 6 кВт:625020
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Светло-серый, DKC_Корпус_Белый, DKC_Корпус_Черный
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Белый; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPG7K8D006A; ADSK_Марка: EOS Power On-grid; ADSK_Масса: 10.9; ADSK_Масса_Текст: 10.9; ADSK_Наименование: Сетевой однофазный солнечный инвертор EOS Power On-grid 6 кВт; ADSK_Наименование краткое: Инвертор EOS Power On-grid 6 кВт
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/583/2t7no00easa0gpt82ziqpr9pb36bs28j.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1740/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power On-grid 6 кВт; Описание: Сетевыми (on-grid) инверторами являются устройства, преобразующие постоянное (DC) напряжение от солнечных панелей в переменное (AC) напряжение, и передающие его напрямую в сеть 220 (или 380) В, с надлежащими значениями частоты и фазы для сопряжения со стационарной сетью, тем самым снижая потребление электроэнергии от энергосетей.
Type - Материалы и отделка - Материал_Дисплей: DKC_Корпус_Черный; Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC; Интерфейсы связи: RS485, Wi-Fi / Ethernet (опционально), GPRS (опционально); Рабочая температура: - 25°С ~ 60°С; Степень защиты: IP 65
Type - Размеры - ADSK_Размер_Высота: 420 mm; ADSK_Размер_Глубина: 126.5 mm; ADSK_Размер_Ширина: 370 mm
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 1; ADSK_Количество фаз числовое: 1; ADSK_Коэффициент мощности: 0.99; ADSK_КПД: 97.3; ADSK_Напряжение: 230 V; ADSK_Номинальная мощность: 6000 W; ADSK_Полная мощность: 6060.61 W; ADSK_Ток: 30 A
Pset_BuildingElementProxyCommon - Reference: EOS Power On-grid 6 кВт
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 7
Прочее - Код типа: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC: EOS Power On-grid 6 кВт; Семейство: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC: EOS Power On-grid 6 кВт; Семейство и типоразмер: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC: EOS Power On-grid 6 кВт; Тип: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC: EOS Power On-grid 6 кВт
Размеры - Объем: 0.0238539 m3; Площадь: 0.276665 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 230 В/1-6061 В·А

# IfcBuildingElementProxy: EOS Power On-grid 7 кВт, EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC:EOS Power On-grid 7 кВт:625021
In: Этаж 01
Type - Material: DKC_Корпус_Красный, DKC_Корпус_Светло-серый, DKC_Корпус_Белый, DKC_Корпус_Черный
Type - Данные - ADSK_Количество: 1; ADSK_Материал: DKC_Корпус_Белый; ADSK_Группирование: Решения для солнечной энергетики; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: DKC; ADSK_Код изделия: EPG7K8D007A; ADSK_Марка: EOS Power On-grid; ADSK_Масса: 10.9; ADSK_Масса_Текст: 10.9; ADSK_Наименование: Сетевой однофазный солнечный инвертор EOS Power On-grid 7 кВт; ADSK_Наименование краткое: Инвертор EOS Power On-grid 7 кВт
Type - Идентификация - ADSK_URL документации изделия: https://www.dkc.ru/upload/iblock/583/2t7no00easa0gpt82ziqpr9pb36bs28j.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1740/; ADSK_Версия Revit: 2019; ADSK_Версия семейства: v.1; BL_BIM library: https://bimlib.pro/manufacturer/dks/d9bb370f-c40f-4814-bb40-30ad412701ed; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/ru/; Изготовитель: DKC; Имя типа: EOS Power On-grid 7 кВт; Описание: Сетевыми (on-grid) инверторами являются устройства, преобразующие постоянное (DC) напряжение от солнечных панелей в переменное (AC) напряжение, и передающие его напрямую в сеть 220 (или 380) В, с надлежащими значениями частоты и фазы для сопряжения со стационарной сетью, тем самым снижая потребление электроэнергии от энергосетей.
Type - Материалы и отделка - Материал_Дисплей: DKC_Корпус_Черный; Материал_Логотип: DKC_Корпус_Красный
Type - Прочее - Категория: Электрооборудование; ETIM Article Class: EC001747; Имя семейства: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC; Интерфейсы связи: RS485, Wi-Fi / Ethernet (опционально), GPRS (опционально); Рабочая температура: - 25°С ~ 60°С; Степень защиты: IP 65
Type - Размеры - ADSK_Размер_Высота: 420 mm; ADSK_Размер_Глубина: 126.5 mm; ADSK_Размер_Ширина: 370 mm
Type - Электросети - Нагрузки - ADSK_Классификация нагрузок: Прочее; ADSK_Количество фаз: 1; ADSK_Количество фаз числовое: 1; ADSK_Коэффициент мощности: 0.99; ADSK_КПД: 97.3; ADSK_Напряжение: 230 V; ADSK_Номинальная мощность: 7000 W; ADSK_Полная мощность: 7070.71 W; ADSK_Ток: 30 A
Pset_BuildingElementProxyCommon - Reference: EOS Power On-grid 7 кВт
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Зависимости - Смещение: 0 mm; Уровень: Уровень: Этаж 01; Основа: Уровень : Этаж 01
Идентификация - Марка: 8
Прочее - Код типа: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC: EOS Power On-grid 7 кВт; Семейство: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC: EOS Power On-grid 7 кВт; Семейство и типоразмер: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC: EOS Power On-grid 7 кВт; Тип: EOS_СолнечныйИнвертор_ОднофазныйСетевой_EOS-Power-On-grid_3-7кВт_DKC: EOS Power On-grid 7 кВт
Размеры - Объем: 0.0238539 m3; Площадь: 0.276665 m2
Стадии - Стадия возведения: Стадия 1
Электросети - Создание цепей - Данные об электрооборудовании: Электрический соединитель 230 В/1-7071 В·А

# IfcBuildingElementProxy: Текст модели:75 мм Arial (7)
In: Этаж 01
Pset_BuildingElementProxyCommon - Reference: 75 мм Arial
Графика - Горизонтальное выравнивание: Влево
Зависимости - Рабочая плоскость: Уровень : Этаж 01
Идентификация - Подкатегория: Обобщенные модели
Материалы и отделка - Материал: DKC_СерыйЛого
Прочее - Категория: Обобщенные модели; Код типа: Текст модели: 75 мм Arial; Семейство: Текст модели: 75 мм Arial; Семейство и типоразмер: Текст модели: 75 мм Arial; Тип: Текст модели: 75 мм Arial
Размеры - Глубина:: 5 mm
Стадии - Стадия возведения: Стадия 1
Текст(Type) - Жирный: no; Курсив: no; Размер текста: 75 mm; Шрифт текста: Arial
Прочее(Type) - Категория: Обобщенные модели; Имя семейства: Текст модели
Идентификация(Type) - Имя типа: 75 мм Arial
Name (Текст модели:...) | Текст | Вариант конструкции
75 мм Arial | 3 кВт | Оформление каталога (основной)
75 мм Arial | 3,6 кВт | Оформление каталога : Оформление каталога
75 мм Arial | 4 кВт | Оформление каталога (основной)
75 мм Arial | 4,6 кВт | Оформление каталога (основной)
75 мм Arial | 5 кВт | Оформление каталога (основной)
75 мм Arial | 6 кВт | Оформление каталога (основной)
75 мм Arial | 7 кВт | Оформление каталога : Оформление каталога
